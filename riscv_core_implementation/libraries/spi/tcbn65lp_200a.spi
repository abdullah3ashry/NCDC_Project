MI4 VDD net30 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt IND3D2 A1 B1 B2 ZN VDD VSS
MI5-M_u2 net30 A1 VSS VSS nch w=0.39u l=0.06u
MI17 net32 B1 net29 VSS nch w=0.39u l=0.06u
MI16 net29 net30 VSS VSS nch w=0.39u l=0.06u
MI18 ZN B2 net32 VSS nch w=0.39u l=0.06u
MI12 ZN B2 net32 VSS nch w=0.39u l=0.06u
MI14 net29 net30 VSS VSS nch w=0.39u l=0.06u
MI13 net32 B1 net29 VSS nch w=0.39u l=0.06u
MI5-M_u3 net30 A1 VDD VDD pch w=0.52u l=0.06u
MI9 VDD B2 ZN VDD pch w=1.04u l=0.06u
MI19 VDD B1 ZN VDD pch w=1.04u l=0.06u
MI20 VDD net30 ZN VDD pch w=1.04u l=0.06u
.ends
.subckt IND3D4 A1 B1 B2 ZN VDD VSS
MI5_0-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI12 ZN B2 net027 VSS nch w=1.56u l=0.06u
MI7 net024 p0 VSS VSS nch w=1.56u l=0.06u
MI6 net027 B1 net024 VSS nch w=1.56u l=0.06u
MI5_0-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI5_1-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI11_0 VDD B2 ZN VDD pch w=0.52u l=0.06u
MI11_1 VDD B2 ZN VDD pch w=0.52u l=0.06u
MI11_2 VDD B2 ZN VDD pch w=0.52u l=0.06u
MI11_3 VDD B2 ZN VDD pch w=0.52u l=0.06u
MI10_0 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI10_1 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI10_2 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI10_3 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI4_0 VDD p0 ZN VDD pch w=0.52u l=0.06u
MI4_1 VDD p0 ZN VDD pch w=0.52u l=0.06u
MI4_2 VDD p0 ZN VDD pch w=0.52u l=0.06u
MI4_3 VDD p0 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt IND4D0 A1 B1 B2 B3 ZN VDD VSS
MI11-M_u2 net20 A1 VSS VSS nch w=0.195u l=0.06u
MU53 ZN B3 p0 VSS nch w=0.195u l=0.06u
MI30 p2 net20 VSS VSS nch w=0.195u l=0.06u
MI29 p1 B1 p2 VSS nch w=0.195u l=0.06u
MI28 p0 B2 p1 VSS nch w=0.195u l=0.06u
MI11-M_u3 net20 A1 VDD VDD pch w=0.26u l=0.06u
MI25 ZN B1 VDD VDD pch w=0.26u l=0.06u
MI27 ZN B3 VDD VDD pch w=0.26u l=0.06u
MI26 ZN B2 VDD VDD pch w=0.26u l=0.06u
MI18 ZN net20 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt IND4D1 A1 B1 B2 B3 ZN VDD VSS
MI12-M_u2 net020 A1 VSS VSS nch w=0.195u l=0.06u
MI10 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI8 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI9 p1 B2 p2 VSS nch w=0.39u l=0.06u
MU53 ZN net020 p0 VSS nch w=0.39u l=0.06u
MI12-M_u3 net020 A1 VDD VDD pch w=0.26u l=0.06u
MI18 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI5 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI6 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI7 ZN net020 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IND4D2 A1 B1 B2 B3 ZN VDD VSS
MI5-M_u2 net020 A1 VSS VSS nch w=0.39u l=0.06u
MU53_0 ZN net020 p0 VSS nch w=0.39u l=0.06u
MU53_1 ZN net020 p0 VSS nch w=0.39u l=0.06u
MI27_0 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI27_1 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI28_0 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI28_1 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI29_0 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI29_1 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI5-M_u3 net020 A1 VDD VDD pch w=0.52u l=0.06u
MI25_0 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI25_1 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI24_0 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI24_1 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI17_0 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI17_1 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI26_0 ZN net020 VDD VDD pch w=0.52u l=0.06u
MI26_1 ZN net020 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IND4D4 A1 B1 B2 B3 ZN VDD VSS
MI5_0-M_u2 p3 A1 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u2 p3 A1 VSS VSS nch w=0.39u l=0.06u
MU53_0 ZN p3 p0 VSS nch w=0.39u l=0.06u
MU53_1 ZN p3 p0 VSS nch w=0.39u l=0.06u
MU53_2 ZN p3 p0 VSS nch w=0.39u l=0.06u
MU53_3 ZN p3 p0 VSS nch w=0.39u l=0.06u
MI26_0 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI26_1 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI26_2 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI26_3 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI27_0 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI27_1 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI27_2 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI27_3 p2 B3 VSS VSS nch w=0.39u l=0.06u
MI25_0 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI25_1 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI25_2 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI25_3 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI5_0-M_u3 p3 A1 VDD VDD pch w=0.52u l=0.06u
MI5_1-M_u3 p3 A1 VDD VDD pch w=0.52u l=0.06u
MI18_0 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI18_1 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI18_2 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI18_3 ZN B3 VDD VDD pch w=0.52u l=0.06u
MI24_0 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI24_1 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI24_2 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI24_3 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI22_0 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI22_1 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI22_2 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI22_3 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI23_0 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI23_1 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI23_2 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI23_3 ZN B1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR2D0 A1 B1 ZN VDD VSS
MU1-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u1 XU1-net8 net4 VDD VDD pch w=0.26u l=0.06u
MU1-M_u2 ZN B1 XU1-net8 VDD pch w=0.26u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt INR2D1 A1 B1 ZN VDD VSS
MU1-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1-M_u3 ZN net4 VSS VSS nch w=0.39u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u1 XU1-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1-M_u2 ZN B1 XU1-net8 VDD pch w=0.52u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt INR2D2 A1 B1 ZN VDD VSS
MU1_0-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN net4 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u3 ZN net4 VSS VSS nch w=0.39u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u1 XU1_0-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u2 ZN B1 XU1_0-net8 VDD pch w=0.52u l=0.06u
MU1_1-M_u1 XU1_1-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u2 ZN B1 XU1_1-net8 VDD pch w=0.52u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR2D4 A1 B1 ZN VDD VSS
MU1_0-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u3 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u3 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u4 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u3 ZN p0 VSS VSS nch w=0.39u l=0.06u
MI5_0-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u1 XU1_0-net8 p0 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u2 ZN B1 XU1_0-net8 VDD pch w=0.52u l=0.06u
MU1_1-M_u1 XU1_1-net8 p0 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u2 ZN B1 XU1_1-net8 VDD pch w=0.52u l=0.06u
MU1_2-M_u1 XU1_2-net8 p0 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u2 ZN B1 XU1_2-net8 VDD pch w=0.52u l=0.06u
MU1_3-M_u1 XU1_3-net8 p0 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u2 ZN B1 XU1_3-net8 VDD pch w=0.52u l=0.06u
MI5_0-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI5_1-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR2XD0 A1 B1 ZN VDD VSS
MU1-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u1 XU1-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1-M_u2 ZN B1 XU1-net8 VDD pch w=0.52u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt INR2XD1 A1 B1 ZN VDD VSS
MU1_0-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU1_1-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_1-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u1 XU1_0-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u2 ZN B1 XU1_0-net8 VDD pch w=0.52u l=0.06u
MU1_1-M_u1 XU1_1-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u2 ZN B1 XU1_1-net8 VDD pch w=0.52u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR2XD2 A1 B1 ZN VDD VSS
MU1_0-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU1_1-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_1-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU1_2-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_2-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU1_3-M_u4 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU1_3-M_u3 ZN net4 VSS VSS nch w=0.195u l=0.06u
MU6-M_u2 net4 A1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u1 XU1_0-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u2 ZN B1 XU1_0-net8 VDD pch w=0.52u l=0.06u
MU1_1-M_u1 XU1_1-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u2 ZN B1 XU1_1-net8 VDD pch w=0.52u l=0.06u
MU1_2-M_u1 XU1_2-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u2 ZN B1 XU1_2-net8 VDD pch w=0.52u l=0.06u
MU1_3-M_u1 XU1_3-net8 net4 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u2 ZN B1 XU1_3-net8 VDD pch w=0.52u l=0.06u
MU6-M_u3 net4 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR2XD4 A1 B1 ZN VDD VSS
MI36-M_u4 ZN p0 VSS VSS nch w=1.56u l=0.06u
MI36-M_u3 ZN B1 VSS VSS nch w=1.56u l=0.06u
MI35_0-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI35_1-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI36-M_u1 XI36-net8 B1 VDD VDD pch w=4.16u l=0.06u
MI36-M_u2 ZN p0 XI36-net8 VDD pch w=4.16u l=0.06u
MI35_0-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI35_1-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR3D0 A1 B1 B2 ZN VDD VSS
MU9-M_u6 ZN B2 VSS VSS nch w=0.195u l=0.06u
MU9-M_u5 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU9-M_u4 ZN net12 VSS VSS nch w=0.195u l=0.06u
MU47-M_u2 net12 A1 VSS VSS nch w=0.195u l=0.06u
MU9-M_u1 XU9-net9 net12 VDD VDD pch w=0.52u l=0.06u
MU9-M_u2 XU9-net12 B1 XU9-net9 VDD pch w=0.52u l=0.06u
MU9-M_u3 ZN B2 XU9-net12 VDD pch w=0.52u l=0.06u
MU47-M_u3 net12 A1 VDD VDD pch w=0.27u l=0.06u
.ends
.subckt INR3D1 A1 B1 B2 ZN VDD VSS
M_u4 ZN net12 VSS VSS nch w=0.39u l=0.06u
MI3 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI4 ZN B2 VSS VSS nch w=0.39u l=0.06u
MU47-M_u2 net12 A1 VSS VSS nch w=0.39u l=0.06u
MU47-M_u3 net12 A1 VDD VDD pch w=0.52u l=0.06u
MI7 net26 net12 VDD VDD pch w=0.52u l=0.06u
MI6 net29 B1 net26 VDD pch w=0.52u l=0.06u
M_u1 net35 net12 VDD VDD pch w=0.52u l=0.06u
MI1 net32 B1 net35 VDD pch w=0.52u l=0.06u
MI2 ZN B2 net32 VDD pch w=0.52u l=0.06u
MI5 ZN B2 net29 VDD pch w=0.52u l=0.06u
.ends
.subckt INR3D2 A1 B1 B2 ZN VDD VSS
M_u4_0 ZN net30 VSS VSS nch w=0.39u l=0.06u
M_u4_1 ZN net30 VSS VSS nch w=0.39u l=0.06u
MI7_0 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI7_1 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI6_0 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI6_1 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net30 A1 VSS VSS nch w=0.39u l=0.06u
MI8 ZN B2 net029 VDD pch w=0.52u l=0.06u
MI9 net029 B1 net026 VDD pch w=0.52u l=0.06u
MI10 net026 net30 VDD VDD pch w=0.52u l=0.06u
MI3 net17 net30 VDD VDD pch w=0.52u l=0.06u
MI5 ZN B2 net20 VDD pch w=0.52u l=0.06u
MI4 net20 B1 net17 VDD pch w=0.52u l=0.06u
MI1-M_u3 net30 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR3D4 A1 B1 B2 ZN VDD VSS
MU9_0-M_u6 ZN B2 VSS VSS nch w=0.39u l=0.06u
MU9_0-M_u5 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU9_0-M_u4 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU9_1-M_u6 ZN B2 VSS VSS nch w=0.39u l=0.06u
MU9_1-M_u5 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU9_1-M_u4 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU9_2-M_u6 ZN B2 VSS VSS nch w=0.39u l=0.06u
MU9_2-M_u5 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU9_2-M_u4 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU9_3-M_u6 ZN B2 VSS VSS nch w=0.39u l=0.06u
MU9_3-M_u5 ZN B1 VSS VSS nch w=0.39u l=0.06u
MU9_3-M_u4 ZN p0 VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MU9_0-M_u1 XU9_0-net9 p0 VDD VDD pch w=0.52u l=0.06u
MU9_0-M_u2 XU9_0-net12 B1 XU9_0-net9 VDD pch w=0.52u l=0.06u
MU9_0-M_u3 ZN B2 XU9_0-net12 VDD pch w=0.52u l=0.06u
MU9_1-M_u1 XU9_1-net9 p0 VDD VDD pch w=0.52u l=0.06u
MU9_1-M_u2 XU9_1-net12 B1 XU9_1-net9 VDD pch w=0.52u l=0.06u
MU9_1-M_u3 ZN B2 XU9_1-net12 VDD pch w=0.52u l=0.06u
MU9_2-M_u1 XU9_2-net9 p0 VDD VDD pch w=0.52u l=0.06u
MU9_2-M_u2 XU9_2-net12 B1 XU9_2-net9 VDD pch w=0.52u l=0.06u
MU9_2-M_u3 ZN B2 XU9_2-net12 VDD pch w=0.52u l=0.06u
MU9_3-M_u1 XU9_3-net9 p0 VDD VDD pch w=0.52u l=0.06u
MU9_3-M_u2 XU9_3-net12 B1 XU9_3-net9 VDD pch w=0.52u l=0.06u
MU9_3-M_u3 ZN B2 XU9_3-net12 VDD pch w=0.52u l=0.06u
MI3_0-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INR4D0 A1 B1 B2 B3 ZN VDD VSS
MU8-M_u4 ZN net15 VSS VSS nch w=0.195u l=0.06u
MU8-M_u3 ZN B1 VSS VSS nch w=0.195u l=0.06u
MU8-M_u5 ZN B2 VSS VSS nch w=0.195u l=0.06u
MU8-M_u8 ZN B3 VSS VSS nch w=0.195u l=0.06u
MU47-M_u2 net15 A1 VSS VSS nch w=0.195u l=0.06u
MU8-M_u7 ZN B3 XU8-net7 VDD pch w=0.52u l=0.06u
MU8-M_u6 XU8-net7 B2 XU8-net10 VDD pch w=0.52u l=0.06u
MU8-M_u2 XU8-net10 B1 XU8-net13 VDD pch w=0.52u l=0.06u
MU8-M_u1 XU8-net13 net15 VDD VDD pch w=0.52u l=0.06u
MU47-M_u3 net15 A1 VDD VDD pch w=0.27u l=0.06u
.ends
.subckt INR4D1 A1 B1 B2 B3 ZN VDD VSS
MI3 ZN net039 VSS VSS nch w=0.23u l=0.06u
MI2 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI1 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI5 ZN B3 VSS VSS nch w=0.23u l=0.06u
MI6-M_u2 net039 A1 VSS VSS nch w=0.195u l=0.06u
MI6-M_u3 net039 A1 VDD VDD pch w=0.26u l=0.06u
MI28 ZN B3 net18 VDD pch w=0.52u l=0.06u
MI26 net21 B1 net39 VDD pch w=0.52u l=0.06u
MI30 net27 B2 net36 VDD pch w=0.52u l=0.06u
MI31 net36 B1 net33 VDD pch w=0.52u l=0.06u
MI32 net33 net039 VDD VDD pch w=0.52u l=0.06u
MI29 ZN B3 net27 VDD pch w=0.52u l=0.06u
MI7 net39 net039 VDD VDD pch w=0.52u l=0.06u
MI27 net18 B2 net21 VDD pch w=0.52u l=0.06u
.ends
.subckt INR4D2 A1 B1 B2 B3 ZN VDD VSS
MI15_0 ZN net036 VSS VSS nch w=0.39u l=0.06u
MI15_1 ZN net036 VSS VSS nch w=0.39u l=0.06u
MI14_0 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI14_1 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI13_0 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI13_1 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI5_0 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI5_1 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u2 net036 A1 VSS VSS nch w=0.39u l=0.06u
MI20-M_u3 net036 A1 VDD VDD pch w=0.52u l=0.06u
MI40 net040 B2 net085 VDD pch w=0.67u l=0.06u
MI23 ZN B3 net040 VDD pch w=0.67u l=0.06u
MI24 ZN B3 net040 VDD pch w=0.67u l=0.06u
MI39 net085 B1 net067 VDD pch w=0.67u l=0.06u
MI26 net067 net036 VDD VDD pch w=0.67u l=0.06u
MI30 net040 B2 net085 VDD pch w=0.67u l=0.06u
MI31 net067 net036 VDD VDD pch w=0.67u l=0.06u
MI32 net085 B1 net067 VDD pch w=0.67u l=0.06u
MI33 ZN B3 net040 VDD pch w=0.67u l=0.06u
MI21 net085 B1 net067 VDD pch w=0.67u l=0.06u
MI7 net067 net036 VDD VDD pch w=0.67u l=0.06u
MI22 net040 B2 net085 VDD pch w=0.67u l=0.06u
.ends
.subckt INR4D4 A1 B1 B2 B3 ZN VDD VSS
MI48 ZN B3 net74 VDD pch w=2.08u l=0.06u
MI46 net65 B1 net71 VDD pch w=2.08u l=0.06u
MI7 net71 net67 VDD VDD pch w=2.08u l=0.06u
MI47 net74 B2 net65 VDD pch w=2.08u l=0.06u
MI20_0-M_u3 net67 A1 VDD VDD pch w=0.52u l=0.06u
MI20_1-M_u3 net67 A1 VDD VDD pch w=0.52u l=0.06u
MI20_0-M_u2 net67 A1 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u2 net67 A1 VSS VSS nch w=0.39u l=0.06u
MI5_0 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI5_1 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI5_2 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI5_3 ZN B3 VSS VSS nch w=0.39u l=0.06u
MI43_0 ZN net67 VSS VSS nch w=0.39u l=0.06u
MI43_1 ZN net67 VSS VSS nch w=0.39u l=0.06u
MI43_2 ZN net67 VSS VSS nch w=0.39u l=0.06u
MI43_3 ZN net67 VSS VSS nch w=0.39u l=0.06u
MI42_0 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI42_1 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI42_2 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI42_3 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI41_0 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI41_1 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI41_2 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI41_3 ZN B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt INVD0 I ZN VDD VSS
MU1-M_u2 ZN I VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 ZN I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt INVD1 I ZN VDD VSS
MU1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD2 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD3 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD4 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD6 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD8 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD12 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_8-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_9-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_10-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_11-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_8-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_9-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_10-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_11-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD16 I ZN VDD VSS
MI2_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_8-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_9-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_10-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_11-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_12-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_13-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_14-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_15-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_8-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_9-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_10-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_11-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_12-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_13-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_14-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MI2_15-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD20 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_8-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_9-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_10-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_11-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_12-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_13-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_14-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_15-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_16-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_17-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_18-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_19-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_8-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_9-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_10-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_11-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_12-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_13-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_14-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_15-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_16-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_17-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_18-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_19-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt INVD24 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_8-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_9-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_10-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_11-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_12-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_13-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_14-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_15-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_16-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_17-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_18-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_19-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_20-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_21-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_22-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_23-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_8-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_9-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_10-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_11-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_12-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_13-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_14-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_15-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_16-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_17-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_18-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_19-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_20-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_21-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_22-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_23-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA21D0 A1 A2 B ZN VDD VSS
MU35-M_u4 XU35-net6 A2 VSS VSS nch w=0.195u l=0.06u
MU35-M_u3 net5 A1 XU35-net6 VSS nch w=0.195u l=0.06u
MU36-M_u4 XU36-net6 net5 VSS VSS nch w=0.195u l=0.06u
MU36-M_u3 ZN B XU36-net6 VSS nch w=0.195u l=0.06u
MU35-M_u2 net5 A2 VDD VDD pch w=0.26u l=0.06u
MU35-M_u1 net5 A1 VDD VDD pch w=0.26u l=0.06u
MU36-M_u2 ZN net5 VDD VDD pch w=0.26u l=0.06u
MU36-M_u1 ZN B VDD VDD pch w=0.26u l=0.06u
.ends
.subckt IOA21D1 A1 A2 B ZN VDD VSS
MU35-M_u4 XU35-net6 A2 VSS VSS nch w=0.195u l=0.06u
MU35-M_u3 net5 A1 XU35-net6 VSS nch w=0.195u l=0.06u
MU36-M_u4 XU36-net6 net5 VSS VSS nch w=0.39u l=0.06u
MU36-M_u3 ZN B XU36-net6 VSS nch w=0.39u l=0.06u
MU35-M_u2 net5 A2 VDD VDD pch w=0.26u l=0.06u
MU35-M_u1 net5 A1 VDD VDD pch w=0.26u l=0.06u
MU36-M_u2 ZN net5 VDD VDD pch w=0.52u l=0.06u
MU36-M_u1 ZN B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA21D2 A1 A2 B ZN VDD VSS
MU35-M_u4 XU35-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU35-M_u3 net5 A1 XU35-net6 VSS nch w=0.39u l=0.06u
MU36_0-M_u4 XU36_0-net6 net5 VSS VSS nch w=0.39u l=0.06u
MU36_0-M_u3 ZN B XU36_0-net6 VSS nch w=0.39u l=0.06u
MU36_1-M_u4 XU36_1-net6 net5 VSS VSS nch w=0.39u l=0.06u
MU36_1-M_u3 ZN B XU36_1-net6 VSS nch w=0.39u l=0.06u
MU35-M_u2 net5 A2 VDD VDD pch w=0.52u l=0.06u
MU35-M_u1 net5 A1 VDD VDD pch w=0.52u l=0.06u
MU36_0-M_u2 ZN net5 VDD VDD pch w=0.52u l=0.06u
MU36_0-M_u1 ZN B VDD VDD pch w=0.52u l=0.06u
MU36_1-M_u2 ZN net5 VDD VDD pch w=0.52u l=0.06u
MU36_1-M_u1 ZN B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA21D4 A1 A2 B ZN VDD VSS
MI1-M_u4 XI1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net42 A1 XI1-net6 VSS nch w=0.39u l=0.06u
MI10 net023 B VSS VSS nch w=1.56u l=0.06u
M_u3 ZN net42 net023 VSS nch w=1.56u l=0.06u
MI1-M_u2 net42 A2 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 net42 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_0 ZN B VDD VDD pch w=0.52u l=0.06u
M_u2_1 ZN B VDD VDD pch w=0.52u l=0.06u
M_u2_2 ZN B VDD VDD pch w=0.52u l=0.06u
M_u2_3 ZN B VDD VDD pch w=0.52u l=0.06u
MI2_0 ZN net42 VDD VDD pch w=0.52u l=0.06u
MI2_1 ZN net42 VDD VDD pch w=0.52u l=0.06u
MI2_2 ZN net42 VDD VDD pch w=0.52u l=0.06u
MI2_3 ZN net42 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA22D0 A1 A2 B1 B2 ZN VDD VSS
MU26 ZN net6 net17 VSS nch w=0.195u l=0.06u
MU29 net17 B2 VSS VSS nch w=0.195u l=0.06u
MU24 net17 B1 VSS VSS nch w=0.195u l=0.06u
MU35-M_u4 XU35-net6 A1 VSS VSS nch w=0.195u l=0.06u
MU35-M_u3 net6 A2 XU35-net6 VSS nch w=0.195u l=0.06u
MU35-M_u2 net6 A1 VDD VDD pch w=0.26u l=0.06u
MU35-M_u1 net6 A2 VDD VDD pch w=0.26u l=0.06u
MU30 ZN net6 VDD VDD pch w=0.26u l=0.06u
MI16-MI12 ZN B2 XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt IOA22D1 A1 A2 B1 B2 ZN VDD VSS
MU26 ZN net6 net17 VSS nch w=0.39u l=0.06u
MU29 net17 B2 VSS VSS nch w=0.39u l=0.06u
MU24 net17 B1 VSS VSS nch w=0.39u l=0.06u
MU35-M_u4 XU35-net6 A1 VSS VSS nch w=0.195u l=0.06u
MU35-M_u3 net6 A2 XU35-net6 VSS nch w=0.195u l=0.06u
MU35-M_u2 net6 A1 VDD VDD pch w=0.26u l=0.06u
MU35-M_u1 net6 A2 VDD VDD pch w=0.26u l=0.06u
MU30 ZN net6 VDD VDD pch w=0.52u l=0.06u
MI16-MI12 ZN B2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA22D2 A1 A2 B1 B2 ZN VDD VSS
MI4 net27 A2 VSS VSS nch w=0.39u l=0.06u
MI3 net30 A1 net27 VSS nch w=0.39u l=0.06u
MU51 net30 net6 VSS VSS nch w=0.39u l=0.06u
MU37_0-M_u2 ZN net30 VSS VSS nch w=0.39u l=0.06u
MU37_1-M_u2 ZN net30 VSS VSS nch w=0.39u l=0.06u
MU56-M_u4 net6 B1 VSS VSS nch w=0.195u l=0.06u
MU56-M_u3 net6 B2 VSS VSS nch w=0.195u l=0.06u
MU37_0-M_u3 ZN net30 VDD VDD pch w=0.52u l=0.06u
MU37_1-M_u3 ZN net30 VDD VDD pch w=0.52u l=0.06u
MU56-M_u1 XU56-net8 B2 VDD VDD pch w=0.52u l=0.06u
MU56-M_u2 net6 B1 XU56-net8 VDD pch w=0.52u l=0.06u
MI2 net30 net6 net16 VDD pch w=0.52u l=0.06u
MU50 net16 A2 VDD VDD pch w=0.52u l=0.06u
MI1 net16 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IOA22D4 A1 A2 B1 B2 ZN VDD VSS
MI13 net026 A2 VSS VSS nch w=0.78u l=0.06u
MI11 p0 A1 net026 VSS nch w=0.78u l=0.06u
MU51_0 p0 net45 VSS VSS nch w=0.39u l=0.06u
MU51_1 p0 net45 VSS VSS nch w=0.39u l=0.06u
MU37_0-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU37_1-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU37_2-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU37_3-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU56-M_u4 net45 B1 VSS VSS nch w=0.195u l=0.06u
MU56-M_u3 net45 B2 VSS VSS nch w=0.195u l=0.06u
MU37_0-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU37_1-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU37_2-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU37_3-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU56-M_u1 XU56-net8 B2 VDD VDD pch w=0.52u l=0.06u
MU56-M_u2 net45 B1 XU56-net8 VDD pch w=0.52u l=0.06u
MI15 p0 net45 net045 VDD pch w=1.04u l=0.06u
MU50 net045 A2 VDD VDD pch w=1.04u l=0.06u
MI14 net045 A1 VDD VDD pch w=1.04u l=0.06u
.ends
.subckt LHCND1 D E CDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.24u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCND2 D E CDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI15 net45 D net045 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI16 net045 CDN VSS VSS nch w=0.24u l=0.06u
MI22-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI21-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI20 net46 net63 net064 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI19 net064 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI22-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI21-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCND4 D E CDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.24u l=0.06u
MI27-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI19-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI20-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI27-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI20-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDD1 D E CDN Q QN VDD VSS
MI6 net46 net071 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI7-M_u2 net071 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net071 net73 VDD pch w=0.15u l=0.06u
MI7-M_u3 net071 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDD2 D E CDN Q QN VDD VSS
MI6 net46 net078 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI15 net45 D net045 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI16 net045 CDN VSS VSS nch w=0.26u l=0.06u
MI23-M_u2 net078 net63 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI21-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI20 net46 net63 net064 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI19 net064 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net078 net73 VDD pch w=0.15u l=0.06u
MI23-M_u3 net078 net63 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI21-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDD4 D E CDN Q QN VDD VSS
MI6 net46 net093 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI35-M_u2 net093 net63 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI19-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI20-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net093 net73 VDD pch w=0.15u l=0.06u
MI35-M_u3 net093 net63 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI20-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDQD1 D E CDN Q VDD VSS
MI6 net46 net069 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI13-M_u2 net069 net63 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net069 net73 VDD pch w=0.15u l=0.06u
MI13-M_u3 net069 net63 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDQD2 D E CDN Q VDD VSS
MI6 net46 net072 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI15-M_u2 net072 net63 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net072 net73 VDD pch w=0.15u l=0.06u
MI15-M_u3 net072 net63 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNDQD4 D E CDN Q VDD VSS
MI6 net46 net080 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI35-M_u2 net080 net63 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net080 net73 VDD pch w=0.15u l=0.06u
MI35-M_u3 net080 net63 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNQD1 D E CDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI12-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.32u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.32u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI12-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNQD2 D E CDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI7-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.32u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.32u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI7-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCNQD4 D E CDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI27-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net36 net46 VSS VSS nch w=0.39u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.32u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.32u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI27-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net36 net46 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSND1 D E CDN SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHCSND2 D E CDN SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSND4 D E CDN SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI36-M_u4 XI36-net6 net46 VSS VSS nch w=0.39u l=0.06u
MI36-M_u3 net36 SDN XI36-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI36-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI36-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNDD1 D E CDN SDN Q QN VDD VSS
MI6 net46 net077 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net077 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net077 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net077 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHCSNDD2 D E CDN SDN Q QN VDD VSS
MI6 net46 net083 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI13-M_u2 net083 net63 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net083 net73 VDD pch w=0.15u l=0.06u
MI13-M_u3 net083 net63 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNDD4 D E CDN SDN Q QN VDD VSS
MI6 net46 net0103 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
MI36-M_u4 XI36-net6 net46 VSS VSS nch w=0.39u l=0.06u
MI36-M_u3 net36 SDN XI36-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI37-M_u2 net0103 net63 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI36-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI36-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net0103 net73 VDD pch w=0.15u l=0.06u
MI37-M_u3 net0103 net63 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNDQD1 D E CDN SDN Q VDD VSS
MI6 net46 net075 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net075 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net075 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net075 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHCSNDQD2 D E CDN SDN Q VDD VSS
MI6 net46 net078 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 net078 net63 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net078 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 net078 net63 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNDQD4 D E CDN SDN Q VDD VSS
MI6 net46 net084 net45 VSS nch w=0.27u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.37u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI34-M_u2 net084 net63 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI28_1-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.28u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.41u l=0.06u
MI18 net46 net084 net73 VDD pch w=0.15u l=0.06u
MI34-M_u3 net084 net63 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI28_1-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNQD1 D E CDN SDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHCSNQD2 D E CDN SDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHCSNQD4 D E CDN SDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.265u l=0.06u
MI10 net51 CDN VSS VSS nch w=0.15u l=0.06u
MI8 net45 D net40 VSS nch w=0.36u l=0.06u
MI29 net48 net36 net51 VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9 net40 CDN VSS VSS nch w=0.26u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI28_1-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net46 CDN VDD VDD pch w=0.26u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.27u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.27u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI28_1-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHD1 D E Q QN VDD VSS
MI2-M_u2 net11 E VSS VSS nch w=0.195u l=0.06u
MU24-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU23-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net34 net11 VSS VSS nch w=0.195u l=0.06u
MI3-M_u2 net20 net15 VSS VSS nch w=0.39u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.24u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.24u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.26u l=0.06u
MU24-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU23-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net34 net11 VDD VDD pch w=0.26u l=0.06u
MI3-M_u3 net20 net15 VDD VDD pch w=0.52u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHD2 D E Q QN VDD VSS
MI2-M_u2 net11 E VSS VSS nch w=0.195u l=0.06u
MU24_0-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_1-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net34 net11 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.39u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.24u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.24u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.26u l=0.06u
MU24_0-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_1-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net34 net11 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.52u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.32u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.32u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHD4 D E Q QN VDD VSS
MI2-M_u2 net11 E VSS VSS nch w=0.39u l=0.06u
MU24_0-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_1-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_2-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_3-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_2-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_3-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net34 net11 VSS VSS nch w=0.39u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.39u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.24u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.24u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.52u l=0.06u
MU24_0-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_1-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_2-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_3-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_2-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_3-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net34 net11 VDD VDD pch w=0.52u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.52u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.32u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.32u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHQD1 D E Q VDD VSS
MI2-M_u2 net11 E VSS VSS nch w=0.195u l=0.06u
MU23-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net34 net11 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.15u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.26u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.26u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.26u l=0.06u
MU23-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net34 net11 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.15u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHQD2 D E Q VDD VSS
MI3-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net11 E VSS VSS nch w=0.195u l=0.06u
MU23-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net34 net11 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.15u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.26u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.26u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI3-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.26u l=0.06u
MU23-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net34 net11 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.15u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHQD4 D E Q VDD VSS
MI2-M_u2 net11 E VSS VSS nch w=0.39u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_2-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_3-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MI3-M_u2 net34 net11 VSS VSS nch w=0.39u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.15u l=0.06u
MU32-MU3 net15 net34 XU32-net16 VSS nch w=0.24u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.24u l=0.06u
MU22-MU3 net15 net11 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net11 E VDD VDD pch w=0.52u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_2-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_3-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MI3-M_u3 net34 net11 VDD VDD pch w=0.52u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.15u l=0.06u
MU32-MU2 net15 net11 XU32-net6 VDD pch w=0.32u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.32u l=0.06u
MU22-MU2 net15 net34 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LHSND1 D E SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.19u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.26u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.26u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSND2 D E SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.19u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.29u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.29u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.39u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.39u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.26u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.26u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSND4 D E SDN Q QN VDD VSS
MI6 net46 E net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.19u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9-M_u4 XI9-net6 net46 VSS VSS nch w=0.39u l=0.06u
MI9-M_u3 net36 SDN XI9-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI9-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.26u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.26u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHSNDD1 D E SDN Q QN VDD VSS
MI6 net46 net062 net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.39u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net062 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.39u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.52u l=0.06u
MI18 net46 net062 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net062 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNDD2 D E SDN Q QN VDD VSS
MI6 net46 net062 net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.39u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net062 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.39u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.52u l=0.06u
MI18 net46 net062 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net062 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNDD4 D E SDN Q QN VDD VSS
MI6 net46 net070 net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.39u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
MI9-M_u4 XI9-net6 net46 VSS VSS nch w=0.39u l=0.06u
MI9-M_u3 net36 SDN XI9-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI10-M_u2 net070 net63 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
MI9-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.39u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.52u l=0.06u
MI18 net46 net070 net73 VDD pch w=0.15u l=0.06u
MI10-M_u3 net070 net63 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHSNDQD1 D E SDN Q VDD VSS
MI6 net46 net060 net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.39u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net060 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.37u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.52u l=0.06u
MI18 net46 net060 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net060 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNDQD2 D E SDN Q VDD VSS
MI6 net46 net060 net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.39u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI4-M_u2 net060 net63 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.37u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.52u l=0.06u
MI18 net46 net060 net73 VDD pch w=0.15u l=0.06u
MI4-M_u3 net060 net63 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNDQD4 D E SDN Q VDD VSS
MI6 net34 net069 net33 VSS nch w=0.19u l=0.06u
MI8 net33 D VSS VSS nch w=0.39u l=0.06u
MI29 net42 net45 VSS VSS nch w=0.15u l=0.06u
MI5 net34 net70 net42 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net34 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net45 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI12-M_u2 net069 net70 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net69 net45 VSS VSS nch w=0.195u l=0.06u
MI28_1-M_u2 net69 net45 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net70 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net45 net34 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net45 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net34 net70 net54 VDD pch w=0.37u l=0.06u
MI17 VDD net45 net53 VDD pch w=0.15u l=0.06u
MI24 net54 D VDD VDD pch w=0.52u l=0.06u
MI18 net34 net069 net53 VDD pch w=0.15u l=0.06u
MI12-M_u3 net069 net70 VDD VDD pch w=0.52u l=0.06u
MI9-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net69 net45 VDD VDD pch w=0.26u l=0.06u
MI28_1-M_u3 net69 net45 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net70 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LHSNQD1 D E SDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.19u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net61 net36 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net61 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.26u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.26u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net61 net36 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net61 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNQD2 D E SDN Q VDD VSS
MI6 net46 E net45 VSS nch w=0.19u l=0.06u
MI8 net45 D VSS VSS nch w=0.19u l=0.06u
MI29 net48 net36 VSS VSS nch w=0.15u l=0.06u
MI5 net46 net63 net48 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net46 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net36 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net64 net36 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net64 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net63 E VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net36 net46 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net36 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net46 net63 net70 VDD pch w=0.26u l=0.06u
MI17 VDD net36 net73 VDD pch w=0.15u l=0.06u
MI24 net70 D VDD VDD pch w=0.26u l=0.06u
MI18 net46 E net73 VDD pch w=0.15u l=0.06u
MI28-M_u3 net64 net36 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net64 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net63 E VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LHSNQD4 D E SDN Q VDD VSS
MI6 net34 E net33 VSS nch w=0.19u l=0.06u
MI8 net33 D VSS VSS nch w=0.19u l=0.06u
MI29 net42 net45 VSS VSS nch w=0.15u l=0.06u
MI5 net34 net70 net42 VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net34 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net45 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI9-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net69 net45 VSS VSS nch w=0.195u l=0.06u
MI28_1-M_u2 net69 net45 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net70 E VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net45 net34 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net45 SDN VDD VDD pch w=0.52u l=0.06u
MI21 net34 net70 net54 VDD pch w=0.26u l=0.06u
MI17 VDD net45 net53 VDD pch w=0.15u l=0.06u
MI24 net54 D VDD VDD pch w=0.26u l=0.06u
MI18 net34 E net53 VDD pch w=0.15u l=0.06u
MI9-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net69 net45 VDD VDD pch w=0.26u l=0.06u
MI28_1-M_u3 net69 net45 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net70 E VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCND1 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCND2 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCND4 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI33-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI33-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDD1 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net069 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net069 net167 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net069 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net069 net167 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDD2 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net069 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net069 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net069 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net069 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDD4 D EN CDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net073 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI33-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 net073 net167 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net073 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI33-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 net073 net167 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDQD1 D EN CDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net067 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI34-M_u2 net067 net167 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI33-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net067 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI34-M_u3 net067 net167 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI33-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDQD2 D EN CDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net067 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net067 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net067 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net067 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNDQD4 D EN CDN Q VDD VSS
MI29 net45 net080 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net078 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI38-M_u2 net077 net080 VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 net077 net080 VSS VSS nch w=0.39u l=0.06u
MI39-M_u2 net078 net167 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net080 net166 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net080 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net078 net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI38-M_u3 net077 net080 VDD VDD pch w=0.52u l=0.06u
MI37-M_u3 net077 net080 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 net078 net167 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net080 net166 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNQD1 D EN CDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI33-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI33-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNQD2 D EN CDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net169 net166 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net169 net166 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCNQD4 D EN CDN Q VDD VSS
MI29 net45 net080 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI38-M_u2 net077 net080 VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 net077 net080 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net080 net166 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net080 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI38-M_u3 net077 net080 VDD VDD pch w=0.52u l=0.06u
MI37-M_u3 net077 net080 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net080 net166 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCSND1 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSND2 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSND4 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI33-M_u4 XI33-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI33-M_u3 net169 SDN XI33-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI32-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI33-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI32-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCSNDD1 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net075 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI32-M_u2 net075 net167 VSS VSS nch w=0.195u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net075 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI32-M_u3 net075 net167 VDD VDD pch w=0.26u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNDD2 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net075 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net075 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net075 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net075 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNDD4 D EN CDN SDN Q QN VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net083 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
MI33-M_u4 XI33-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI33-M_u3 net169 SDN XI33-net6 VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI32-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net083 net167 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI33-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net083 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI32-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net083 net167 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCSNDQD1 D EN CDN SDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net073 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net073 net167 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net073 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net073 net167 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNDQD2 D EN CDN SDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net073 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net073 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net073 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net073 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNDQD4 D EN CDN SDN Q VDD VSS
MI29 net45 net056 net40 VSS nch w=0.15u l=0.06u
MI5 net166 net082 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.27u l=0.06u
MI8 net171 D net51 VSS nch w=0.37u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.26u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net056 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net083 net056 VSS VSS nch w=0.39u l=0.06u
MI28_1-M_u2 net083 net056 VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 net082 net167 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net056 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net056 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net056 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net082 net110 VDD pch w=0.28u l=0.06u
MI24 net110 D VDD VDD pch w=0.41u l=0.06u
MI28_0-M_u3 net083 net056 VDD VDD pch w=0.52u l=0.06u
MI28_1-M_u3 net083 net056 VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 net082 net167 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNCSNQD1 D EN CDN SDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNQD2 D EN CDN SDN Q VDD VSS
MI29 net45 net169 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNCSNQD4 D EN CDN SDN Q VDD VSS
MI29 net45 net056 net40 VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.265u l=0.06u
MI8 net171 D net51 VSS nch w=0.36u l=0.06u
MI9 net51 CDN VSS VSS nch w=0.24u l=0.06u
MI10 net40 CDN VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net056 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net083 net056 VSS VSS nch w=0.195u l=0.06u
MI28_1-M_u2 net083 net056 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net083 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net056 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net056 SDN VDD VDD pch w=0.52u l=0.06u
MI30 net166 CDN VDD VDD pch w=0.26u l=0.06u
MI17 VDD net056 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.27u l=0.06u
MI24 net110 D VDD VDD pch w=0.27u l=0.06u
MI28_0-M_u3 net083 net056 VDD VDD pch w=0.26u l=0.06u
MI28_1-M_u3 net083 net056 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net083 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LND1 D EN Q QN VDD VSS
MI3-M_u2 net9 EN VSS VSS nch w=0.195u l=0.06u
MU23-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU24-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net30 net9 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.195u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI3-M_u3 net9 EN VDD VDD pch w=0.26u l=0.06u
MU23-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU24-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net30 net9 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.26u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LND2 D EN Q QN VDD VSS
MI3-M_u2 net9 EN VSS VSS nch w=0.195u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU24_0-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_1-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net30 net9 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.39u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI3-M_u3 net9 EN VDD VDD pch w=0.26u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU24_0-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_1-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net30 net9 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.52u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LND4 D EN Q QN VDD VSS
MI2-M_u2 net9 EN VSS VSS nch w=0.39u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_2-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_3-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU24_0-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_1-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_2-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU24_3-M_u2 QN net20 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net30 net9 VSS VSS nch w=0.39u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.39u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net9 EN VDD VDD pch w=0.52u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_2-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_3-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU24_0-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_1-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_2-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU24_3-M_u3 QN net20 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net30 net9 VDD VDD pch w=0.52u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.52u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LNQD1 D EN Q VDD VSS
MI2-M_u2 net9 EN VSS VSS nch w=0.195u l=0.06u
MU23-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net30 net9 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.15u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net9 EN VDD VDD pch w=0.26u l=0.06u
MU23-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net30 net9 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.15u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LNQD2 D EN Q VDD VSS
MI3-M_u2 net9 EN VSS VSS nch w=0.195u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net30 net9 VSS VSS nch w=0.195u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.15u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI3-M_u3 net9 EN VDD VDD pch w=0.26u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net30 net9 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.15u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LNQD4 D EN Q VDD VSS
MI2-M_u2 net9 EN VSS VSS nch w=0.39u l=0.06u
MU23_0-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_1-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_2-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU23_3-M_u2 Q net15 VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net30 net9 VSS VSS nch w=0.39u l=0.06u
MU30-M_u2 net20 net15 VSS VSS nch w=0.195u l=0.06u
MU32-MU3 net15 net9 XU32-net16 VSS nch w=0.23u l=0.06u
MU32-MU4 XU32-net16 D VSS VSS nch w=0.23u l=0.06u
MU22-MU3 net15 net30 XU22-net16 VSS nch w=0.15u l=0.06u
MU22-MU4 XU22-net16 net20 VSS VSS nch w=0.15u l=0.06u
MI2-M_u3 net9 EN VDD VDD pch w=0.52u l=0.06u
MU23_0-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_1-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_2-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU23_3-M_u3 Q net15 VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net30 net9 VDD VDD pch w=0.52u l=0.06u
MU30-M_u3 net20 net15 VDD VDD pch w=0.26u l=0.06u
MU32-MU2 net15 net30 XU32-net6 VDD pch w=0.34u l=0.06u
MU32-MU1 XU32-net6 D VDD VDD pch w=0.34u l=0.06u
MU22-MU2 net15 net9 XU22-net6 VDD pch w=0.15u l=0.06u
MU22-MU1 XU22-net6 net20 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LNSND1 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.325u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.325u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.445u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.445u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSND2 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.325u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.325u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.445u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.445u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSND4 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
MI34-M_u4 XI34-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI34-M_u3 net169 SDN XI34-net6 VSS nch w=0.39u l=0.06u
MI35-M_u4 XI35-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI35-M_u3 net169 SDN XI35-net6 VSS nch w=0.39u l=0.06u
MI33-M_u2 net070 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net070 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI34-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI35-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI35-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net070 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net070 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNSNDD1 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net061 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net061 net167 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net061 net110 VDD pch w=0.39u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net061 net167 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNDD2 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net061 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net061 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net061 net110 VDD pch w=0.39u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net061 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNDD4 D EN SDN Q QN VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net069 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
MI34-M_u4 XI34-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI34-M_u3 net169 SDN XI34-net6 VSS nch w=0.39u l=0.06u
MI35-M_u4 XI35-net6 net166 VSS VSS nch w=0.39u l=0.06u
MI35-M_u3 net169 SDN XI35-net6 VSS nch w=0.39u l=0.06u
MI33-M_u2 net070 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net070 net169 VSS VSS nch w=0.39u l=0.06u
MI36-M_u2 net069 net167 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Q net070 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_2-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI12_3-M_u2 QN net169 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI34-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI35-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
MI35-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net069 net110 VDD pch w=0.39u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 net070 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net070 net169 VDD VDD pch w=0.52u l=0.06u
MI36-M_u3 net069 net167 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Q net070 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_2-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI12_3-M_u3 QN net169 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNSNDQD1 D EN SDN Q VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net059 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net059 net167 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net059 net110 VDD pch w=0.37u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net059 net167 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNDQD2 D EN SDN Q VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net059 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 net059 net167 VSS VSS nch w=0.195u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net059 net110 VDD pch w=0.37u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net059 net167 VDD VDD pch w=0.26u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNDQD4 D EN SDN Q VDD VSS
MI29 net45 net045 VSS VSS nch w=0.15u l=0.06u
MI5 net166 net068 net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net045 SDN X_u2-net6 VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net069 net045 VSS VSS nch w=0.195u l=0.06u
MI28_1-M_u2 net069 net045 VSS VSS nch w=0.195u l=0.06u
MI35-M_u2 net068 net167 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net045 net166 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net045 SDN VDD VDD pch w=0.52u l=0.06u
MI17 VDD net045 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 net068 net110 VDD pch w=0.37u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net069 net045 VDD VDD pch w=0.26u l=0.06u
MI28_1-M_u3 net069 net045 VDD VDD pch w=0.26u l=0.06u
MI35-M_u3 net068 net167 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LNSNQD1 D EN SDN Q VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.325u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.325u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.445u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.445u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNQD2 D EN SDN Q VDD VSS
MI29 net45 net169 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.19u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.325u l=0.06u
M_u2-M_u3 net169 SDN X_u2-net6 VSS nch w=0.325u l=0.06u
MI28-M_u2 net170 net169 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net169 net166 VDD VDD pch w=0.445u l=0.06u
M_u2-M_u1 net169 SDN VDD VDD pch w=0.445u l=0.06u
MI17 VDD net169 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net170 net169 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LNSNQD4 D EN SDN Q VDD VSS
MI29 net45 net045 VSS VSS nch w=0.15u l=0.06u
MI5 net166 EN net45 VSS nch w=0.15u l=0.06u
MI6 net166 net167 net171 VSS nch w=0.15u l=0.06u
MI8 net171 D VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 net166 VSS VSS nch w=0.325u l=0.06u
M_u2-M_u3 net045 SDN X_u2-net6 VSS nch w=0.325u l=0.06u
MI33-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u2 net069 net045 VSS VSS nch w=0.195u l=0.06u
MI28_1-M_u2 net069 net045 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net167 EN VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 Q net069 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net045 net166 VDD VDD pch w=0.445u l=0.06u
M_u2-M_u1 net045 SDN VDD VDD pch w=0.445u l=0.06u
MI17 VDD net045 net106 VDD pch w=0.15u l=0.06u
MI18 net166 net167 net106 VDD pch w=0.15u l=0.06u
MI21 net166 EN net110 VDD pch w=0.22u l=0.06u
MI24 net110 D VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI28_0-M_u3 net069 net045 VDD VDD pch w=0.26u l=0.06u
MI28_1-M_u3 net069 net045 VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net167 EN VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 Q net069 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MAOI222D0 A B C ZN VDD VSS
MU10 net26 C VSS VSS nch w=0.195u l=0.06u
MU9 net26 A ZN VSS nch w=0.195u l=0.06u
MU8 net26 B ZN VSS nch w=0.195u l=0.06u
MU6 ZN A net38 VSS nch w=0.195u l=0.06u
MU7 net38 B VSS VSS nch w=0.195u l=0.06u
MU2 net16 B VDD VDD pch w=0.26u l=0.06u
MU5 net20 A ZN VDD pch w=0.26u l=0.06u
MU3 ZN A net16 VDD pch w=0.26u l=0.06u
MU4 net20 B ZN VDD pch w=0.26u l=0.06u
MU1 net20 C VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MAOI222D1 A B C ZN VDD VSS
MI5 net26 C VSS VSS nch w=0.21u l=0.06u
MU9 net26 A ZN VSS nch w=0.39u l=0.06u
MI1 net26 B ZN VSS nch w=0.21u l=0.06u
MU6 ZN A net38 VSS nch w=0.39u l=0.06u
MI4 net38 B VSS VSS nch w=0.21u l=0.06u
MU2 net16 B VDD VDD pch w=0.455u l=0.06u
MU5 net20 A ZN VDD pch w=0.455u l=0.06u
MI2 ZN A net16 VDD pch w=0.455u l=0.06u
MU4 net20 B ZN VDD pch w=0.455u l=0.06u
MI3 net20 C VDD VDD pch w=0.455u l=0.06u
.ends
.subckt MAOI222D2 A B C ZN VDD VSS
MU10 net26 C VSS VSS nch w=0.21u l=0.06u
MU9 net26 A net31 VSS nch w=0.39u l=0.06u
MU8 net26 B net31 VSS nch w=0.21u l=0.06u
MU6 net31 A net38 VSS nch w=0.39u l=0.06u
MU7 net38 B VSS VSS nch w=0.21u l=0.06u
MU20_0-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU20_1-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net58 net31 VSS VSS nch w=0.39u l=0.06u
MU20_0-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU20_1-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net58 net31 VDD VDD pch w=0.52u l=0.06u
MU2 net16 B VDD VDD pch w=0.455u l=0.06u
MU5 net20 A net31 VDD pch w=0.455u l=0.06u
MU3 net31 A net16 VDD pch w=0.455u l=0.06u
MU4 net20 B net31 VDD pch w=0.455u l=0.06u
MU1 net20 C VDD VDD pch w=0.455u l=0.06u
.ends
.subckt MAOI222D4 A B C ZN VDD VSS
MI4 net31 A net38 VSS nch w=0.39u l=0.06u
MU10 net26 C VSS VSS nch w=0.21u l=0.06u
MI3 net26 A net31 VSS nch w=0.39u l=0.06u
MU8 net26 B net31 VSS nch w=0.21u l=0.06u
MU7 net38 B VSS VSS nch w=0.21u l=0.06u
MU20_0-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU20_1-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU20_2-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU20_3-M_u2 ZN net58 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net58 net31 VSS VSS nch w=0.39u l=0.06u
MU20_0-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU20_1-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU20_2-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU20_3-M_u3 ZN net58 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net58 net31 VDD VDD pch w=0.52u l=0.06u
MU2 net16 B VDD VDD pch w=0.455u l=0.06u
MI2 net31 A net16 VDD pch w=0.455u l=0.06u
MI1 net20 A net31 VDD pch w=0.455u l=0.06u
MU4 net20 B net31 VDD pch w=0.455u l=0.06u
MU1 net20 C VDD VDD pch w=0.455u l=0.06u
.ends
.subckt MAOI22D0 A1 A2 B1 B2 ZN VDD VSS
MI18 net17 B2 VSS VSS nch w=0.195u l=0.06u
MI12 net17 B1 VSS VSS nch w=0.195u l=0.06u
MI20 net63 A2 VSS VSS nch w=0.195u l=0.06u
MI21 ZN net17 VSS VSS nch w=0.195u l=0.06u
MI19 ZN A1 net63 VSS nch w=0.195u l=0.06u
MI16 ZN A2 net31 VDD pch w=0.26u l=0.06u
MI1 net39 B2 VDD VDD pch w=0.26u l=0.06u
MI15 net31 net17 VDD VDD pch w=0.26u l=0.06u
MI17 ZN A1 net31 VDD pch w=0.26u l=0.06u
MI14 net17 B1 net39 VDD pch w=0.26u l=0.06u
.ends
.subckt MAOI22D1 A1 A2 B1 B2 ZN VDD VSS
MI11 net17 B2 VSS VSS nch w=0.39u l=0.06u
MI12 net17 B1 VSS VSS nch w=0.39u l=0.06u
MI9 net63 A2 VSS VSS nch w=0.39u l=0.06u
MI10 ZN net17 VSS VSS nch w=0.39u l=0.06u
MI3 ZN A1 net63 VSS nch w=0.39u l=0.06u
MI6 ZN A2 net31 VDD pch w=0.52u l=0.06u
MI1 net39 B2 VDD VDD pch w=0.52u l=0.06u
MI5 net17 B1 net39 VDD pch w=0.52u l=0.06u
MI13 net31 net17 VDD VDD pch w=0.52u l=0.06u
MI7 ZN A1 net31 VDD pch w=0.52u l=0.06u
.ends
.subckt MAOI22D2 A1 A2 B1 B2 ZN VDD VSS
MU16_0-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MU16_1-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI1 net37 A1 net67 VSS nch w=0.39u l=0.06u
MI2 net67 A2 VSS VSS nch w=0.39u l=0.06u
MU10 net22 B2 net25 VSS nch w=0.39u l=0.06u
MU9 net22 B1 net25 VSS nch w=0.39u l=0.06u
MU8 net22 net37 VSS VSS nch w=0.39u l=0.06u
MU16_0-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MU16_1-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI5 net50 B1 net25 VDD pch w=0.52u l=0.06u
MI4 VDD B2 net50 VDD pch w=0.52u l=0.06u
MU5 net25 net37 VDD VDD pch w=0.52u l=0.06u
MU4 net37 A1 VDD VDD pch w=0.52u l=0.06u
MU3 net37 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MAOI22D4 A1 A2 B1 B2 ZN VDD VSS
MU16_0-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MU16_1-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MU16_2-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MU16_3-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI1 net37 A1 net67 VSS nch w=0.39u l=0.06u
MI2 net67 A2 VSS VSS nch w=0.39u l=0.06u
MU10 net22 B2 net25 VSS nch w=0.39u l=0.06u
MU9 net22 B1 net25 VSS nch w=0.39u l=0.06u
MU8 net22 net37 VSS VSS nch w=0.39u l=0.06u
MU16_0-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MU16_1-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MU16_2-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MU16_3-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI5 net50 B1 net25 VDD pch w=0.52u l=0.06u
MI4 VDD B2 net50 VDD pch w=0.52u l=0.06u
MU5 net25 net37 VDD VDD pch w=0.52u l=0.06u
MU4 net37 A1 VDD VDD pch w=0.52u l=0.06u
MU3 net37 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MOAI22D0 A1 A2 B1 B2 ZN VDD VSS
MU1 net8 B1 net26 VSS nch w=0.195u l=0.06u
MI5 net26 B2 VSS VSS nch w=0.195u l=0.06u
MI6 net29 net8 VSS VSS nch w=0.195u l=0.06u
MU9 net29 A1 ZN VSS nch w=0.195u l=0.06u
MU10 net29 A2 ZN VSS nch w=0.195u l=0.06u
MU3 net8 B2 VDD VDD pch w=0.26u l=0.06u
MI1 net8 B1 VDD VDD pch w=0.26u l=0.06u
MI2 ZN net8 VDD VDD pch w=0.26u l=0.06u
MI4 ZN A1 net20 VDD pch w=0.26u l=0.06u
MI3 net20 A2 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MOAI22D1 A1 A2 B1 B2 ZN VDD VSS
MU1 net8 B1 net26 VSS nch w=0.39u l=0.06u
MI5 net26 B2 VSS VSS nch w=0.39u l=0.06u
MI6 net29 net8 VSS VSS nch w=0.39u l=0.06u
MU9 net29 A1 ZN VSS nch w=0.39u l=0.06u
MU10 net29 A2 ZN VSS nch w=0.39u l=0.06u
MU3 net8 B2 VDD VDD pch w=0.52u l=0.06u
MI1 net8 B1 VDD VDD pch w=0.52u l=0.06u
MI2 ZN net8 VDD VDD pch w=0.52u l=0.06u
MI4 ZN A1 net20 VDD pch w=0.52u l=0.06u
MI3 net20 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MOAI22D2 A1 A2 B1 B2 ZN VDD VSS
MU18_0-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU6 net22 B1 net13 VSS nch w=0.39u l=0.06u
MU7 net13 B2 VSS VSS nch w=0.39u l=0.06u
MU8 net16 A1 VSS VSS nch w=0.39u l=0.06u
MU9 net16 A2 VSS VSS nch w=0.39u l=0.06u
MU5 net22 net16 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU4 net22 B1 net31 VDD pch w=0.52u l=0.06u
MU1 net31 net16 VDD VDD pch w=0.52u l=0.06u
MU2 net31 B2 net22 VDD pch w=0.52u l=0.06u
MU10 net36 A1 VDD VDD pch w=0.52u l=0.06u
MU11 net16 A2 net36 VDD pch w=0.52u l=0.06u
.ends
.subckt MOAI22D4 A1 A2 B1 B2 ZN VDD VSS
MU18_0-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 ZN net22 VSS VSS nch w=0.39u l=0.06u
MU6 net22 B1 net13 VSS nch w=0.39u l=0.06u
MU7 net13 B2 VSS VSS nch w=0.39u l=0.06u
MU8 net16 A1 VSS VSS nch w=0.39u l=0.06u
MU9 net16 A2 VSS VSS nch w=0.39u l=0.06u
MU5 net22 net16 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 ZN net22 VDD VDD pch w=0.52u l=0.06u
MU4 net22 B1 net31 VDD pch w=0.52u l=0.06u
MU1 net31 net16 VDD VDD pch w=0.52u l=0.06u
MU2 net31 B2 net22 VDD pch w=0.52u l=0.06u
MU10 net36 A1 VDD VDD pch w=0.52u l=0.06u
MU11 net16 A2 net36 VDD pch w=0.52u l=0.06u
.ends
.subckt MUX2D0 I0 I1 S Z VDD VSS
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29-M_u2 Z net28 VSS VSS nch w=0.195u l=0.06u
MI19 net026 I0 VSS VSS nch w=0.195u l=0.06u
MI20 net023 I1 VSS VSS nch w=0.195u l=0.06u
MI12 net28 net6 net026 VSS nch w=0.195u l=0.06u
MI21 net28 S net023 VSS nch w=0.195u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.25u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.26u l=0.06u
MI111 net042 I0 VDD VDD pch w=0.26u l=0.06u
MI5 net28 S net042 VDD pch w=0.26u l=0.06u
MI25 net28 net6 net033 VDD pch w=0.26u l=0.06u
MI24 net033 I1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX2D1 I0 I1 S Z VDD VSS
MI14-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net47 I0 VSS VSS nch w=0.23u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU18-M_u3 net47 net6 net28 VSS nch w=0.26u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.24u l=0.06u
MI14-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 net47 I0 VDD VDD pch w=0.31u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU18-M_u2 net47 S net28 VDD pch w=0.41u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.34u l=0.06u
.ends
.subckt MUX2D2 I0 I1 S Z VDD VSS
MI17-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net47 I0 VSS VSS nch w=0.23u l=0.06u
MU29_0-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_1-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.24u l=0.06u
MU18-M_u3 net47 net6 net28 VSS nch w=0.23u l=0.06u
MI17-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 net47 I0 VDD VDD pch w=0.34u l=0.06u
MU29_0-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_1-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.35u l=0.06u
MU18-M_u2 net47 S net28 VDD pch w=0.41u l=0.06u
.ends
.subckt MUX2D4 I0 I1 S Z VDD VSS
MU18-M_u3 net47 net6 net28 VSS nch w=0.26u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.23u l=0.06u
MI14_0-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI14_1-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 net47 I0 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net47 I0 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29_0-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_1-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_2-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_3-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 net47 S net28 VDD pch w=0.41u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.34u l=0.06u
MI14_0-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI14_1-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net47 I0 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net47 I0 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MU29_0-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_1-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_2-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_3-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MUX2ND0 I0 I1 S ZN VDD VSS
MI15-M_u2 net19 S VSS VSS nch w=0.21u l=0.06u
MI21 ZN S net40 VSS nch w=0.23u l=0.06u
MI12 ZN net19 net36 VSS nch w=0.23u l=0.06u
MI20 net40 I1 VSS VSS nch w=0.39u l=0.06u
MI19 net36 I0 VSS VSS nch w=0.23u l=0.06u
MI15-M_u3 net19 S VDD VDD pch w=0.26u l=0.06u
MI25 ZN net19 net26 VDD pch w=0.39u l=0.06u
MI24 net26 I1 VDD VDD pch w=0.52u l=0.06u
MI5 ZN S net30 VDD pch w=0.39u l=0.06u
MI111 net30 I0 VDD VDD pch w=0.31u l=0.06u
.ends
.subckt MUX2ND1 I0 I1 S ZN VDD VSS
MI16-M_u2 net48 net28 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI17-M_u2 net47 I0 VSS VSS nch w=0.23u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29-M_u2 ZN net48 VSS VSS nch w=0.39u l=0.06u
MI18-M_u3 net47 net6 net28 VSS nch w=0.23u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.24u l=0.06u
MI16-M_u3 net48 net28 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI17-M_u3 net47 I0 VDD VDD pch w=0.34u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MU29-M_u3 ZN net48 VDD VDD pch w=0.52u l=0.06u
MI18-M_u2 net47 S net28 VDD pch w=0.41u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.35u l=0.06u
.ends
.subckt MUX2ND2 I0 I1 S ZN VDD VSS
MI16-M_u2 net27 net28 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI18-M_u2 net47 I0 VSS VSS nch w=0.23u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29_0-M_u2 ZN net27 VSS VSS nch w=0.39u l=0.06u
MU29_1-M_u2 ZN net27 VSS VSS nch w=0.39u l=0.06u
MU18-M_u3 net47 net6 net28 VSS nch w=0.23u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.24u l=0.06u
MI16-M_u3 net27 net28 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI18-M_u3 net47 I0 VDD VDD pch w=0.34u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MU29_0-M_u3 ZN net27 VDD VDD pch w=0.52u l=0.06u
MU29_1-M_u3 ZN net27 VDD VDD pch w=0.52u l=0.06u
MU18-M_u2 net47 S net28 VDD pch w=0.22u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.35u l=0.06u
.ends
.subckt MUX2ND4 I0 I1 S ZN VDD VSS
MU18-M_u3 net38 net25 net33 VSS nch w=0.26u l=0.06u
MI25-M_u3 net34 S net33 VSS nch w=0.23u l=0.06u
MI14_0-M_u2 net34 I1 VSS VSS nch w=0.39u l=0.06u
MI14_1-M_u2 net34 I1 VSS VSS nch w=0.39u l=0.06u
MI22_0-M_u2 p0 net33 VSS VSS nch w=0.39u l=0.06u
MI22_1-M_u2 p0 net33 VSS VSS nch w=0.39u l=0.06u
MI23_0-M_u2 net38 I0 VSS VSS nch w=0.39u l=0.06u
MI23_1-M_u2 net38 I0 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net25 S VSS VSS nch w=0.195u l=0.06u
MU29_0-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU29_1-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU29_2-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU29_3-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 net38 S net33 VDD pch w=0.41u l=0.06u
MI25-M_u2 net34 net25 net33 VDD pch w=0.34u l=0.06u
MI14_0-M_u3 net34 I1 VDD VDD pch w=0.52u l=0.06u
MI14_1-M_u3 net34 I1 VDD VDD pch w=0.52u l=0.06u
MI22_0-M_u3 p0 net33 VDD VDD pch w=0.52u l=0.06u
MI22_1-M_u3 p0 net33 VDD VDD pch w=0.52u l=0.06u
MI23_0-M_u3 net38 I0 VDD VDD pch w=0.52u l=0.06u
MI23_1-M_u3 net38 I0 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net25 S VDD VDD pch w=0.26u l=0.06u
MU29_0-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU29_1-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU29_2-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU29_3-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MUX3D0 I0 I1 I2 S0 S1 Z VDD VSS
MI18-M_u2 PG2 I2 VSS VSS nch w=0.195u l=0.06u
MI16-M_u2 net55 I1 VSS VSS nch w=0.195u l=0.06u
MI15-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MU18-M_u2 Z OUT VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net53 I0 VSS VSS nch w=0.195u l=0.06u
MI17-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI5-M_u3 net53 net51 PG1 VSS nch w=0.195u l=0.06u
MI19-M_u3 net55 S0 PG1 VSS nch w=0.195u l=0.06u
MI21-M_u3 PG2 S1 OUT VSS nch w=0.195u l=0.06u
MI20-M_u3 PG1 net29 OUT VSS nch w=0.195u l=0.06u
MI18-M_u3 PG2 I2 VDD VDD pch w=0.26u l=0.06u
MI16-M_u3 net55 I1 VDD VDD pch w=0.26u l=0.06u
MI15-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MU18-M_u3 Z OUT VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net53 I0 VDD VDD pch w=0.26u l=0.06u
MI17-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
MI5-M_u2 net53 S0 PG1 VDD pch w=0.26u l=0.06u
MI19-M_u2 net55 net51 PG1 VDD pch w=0.26u l=0.06u
MI21-M_u2 PG2 net29 OUT VDD pch w=0.26u l=0.06u
MI20-M_u2 PG1 S1 OUT VDD pch w=0.26u l=0.06u
.ends
.subckt MUX3D1 I0 I1 I2 S0 S1 Z VDD VSS
MI12-M_u2 net53 I0 VSS VSS nch w=0.23u l=0.06u
MI3-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU95-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI22-M_u3 net53 net51 PG1 VSS nch w=0.23u l=0.06u
MI4-M_u3 net55 S0 PG1 VSS nch w=0.24u l=0.06u
MI5-M_u3 PG1 net29 OUT VSS nch w=0.21u l=0.06u
MI6-M_u3 PG2 S1 OUT VSS nch w=0.32u l=0.06u
MI12-M_u3 net53 I0 VDD VDD pch w=0.34u l=0.06u
MI3-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU95-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
MI22-M_u2 net53 S0 PG1 VDD pch w=0.41u l=0.06u
MI4-M_u2 net55 net51 PG1 VDD pch w=0.35u l=0.06u
MI5-M_u2 PG1 S1 OUT VDD pch w=0.26u l=0.06u
MI6-M_u2 PG2 net29 OUT VDD pch w=0.44u l=0.06u
.ends
.subckt MUX3D2 I0 I1 I2 S0 S1 Z VDD VSS
MI22-M_u3 net53 net51 PG1 VSS nch w=0.23u l=0.06u
MI12-M_u3 net55 S0 PG1 VSS nch w=0.24u l=0.06u
MI13-M_u3 PG1 net29 OUT VSS nch w=0.21u l=0.06u
MI14-M_u3 PG2 S1 OUT VSS nch w=0.32u l=0.06u
MI8-M_u2 net53 I0 VSS VSS nch w=0.23u l=0.06u
MI15-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI3-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU95-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI22-M_u2 net53 S0 PG1 VDD pch w=0.22u l=0.06u
MI12-M_u2 net55 net51 PG1 VDD pch w=0.35u l=0.06u
MI13-M_u2 PG1 S1 OUT VDD pch w=0.26u l=0.06u
MI14-M_u2 PG2 net29 OUT VDD pch w=0.44u l=0.06u
MI8-M_u3 net53 I0 VDD VDD pch w=0.34u l=0.06u
MI15-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI3-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU95-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX3D4 I0 I1 I2 S0 S1 Z VDD VSS
MI14-M_u3 PG2 S1 OUT VSS nch w=0.21u l=0.06u
MI12-M_u3 net55 S0 PG1 VSS nch w=0.21u l=0.06u
MI5-M_u3 net53 net51 PG1 VSS nch w=0.32u l=0.06u
MI13-M_u3 PG1 net29 OUT VSS nch w=0.32u l=0.06u
MI4_0-M_u2 net53 I0 VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 net53 I0 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI3_0-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 Z OUT VSS VSS nch w=0.39u l=0.06u
MU95_0-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU95_1-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 PG2 net29 OUT VDD pch w=0.34u l=0.06u
MI12-M_u2 net55 net51 PG1 VDD pch w=0.34u l=0.06u
MI5-M_u2 net53 S0 PG1 VDD pch w=0.44u l=0.06u
MI13-M_u2 PG1 S1 OUT VDD pch w=0.44u l=0.06u
MI4_0-M_u3 net53 I0 VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 net53 I0 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI3_0-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 Z OUT VDD VDD pch w=0.52u l=0.06u
MU95_0-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU95_1-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX3ND0 I0 I1 I2 S0 S1 ZN VDD VSS
MI16-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net51 S0 VSS VSS nch w=0.21u l=0.06u
MI15-M_u2 net53 I0 VSS VSS nch w=0.23u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.39u l=0.06u
MI5-M_u3 net53 net51 PG1 VSS nch w=0.26u l=0.06u
MI17-M_u3 net55 S0 PG1 VSS nch w=0.24u l=0.06u
MI19-M_u3 PG2 S1 ZN VSS nch w=0.21u l=0.06u
MI18-M_u3 PG1 net29 ZN VSS nch w=0.21u l=0.06u
MI16-M_u3 PG2 I2 VDD VDD pch w=0.54u l=0.06u
MI12-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI15-M_u3 net53 I0 VDD VDD pch w=0.31u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
MI5-M_u2 net53 S0 PG1 VDD pch w=0.41u l=0.06u
MI17-M_u2 net55 net51 PG1 VDD pch w=0.36u l=0.06u
MI19-M_u2 PG2 net29 ZN VDD pch w=0.28u l=0.06u
MI18-M_u2 PG1 S1 ZN VDD pch w=0.28u l=0.06u
.ends
.subckt MUX3ND1 I0 I1 I2 S0 S1 ZN VDD VSS
MI11-M_u3 PG1 net29 net59 VSS nch w=0.21u l=0.06u
MI12-M_u3 PG2 S1 net59 VSS nch w=0.32u l=0.06u
MI9-M_u3 net55 S0 PG1 VSS nch w=0.24u l=0.06u
MI8-M_u3 net53 net51 PG1 VSS nch w=0.22u l=0.06u
MI16-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI4-M_u2 net33 net59 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net53 I0 VSS VSS nch w=0.22u l=0.06u
MI14-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI6-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.175u l=0.06u
MI11-M_u2 PG1 S1 net59 VDD pch w=0.26u l=0.06u
MI12-M_u2 PG2 net29 net59 VDD pch w=0.44u l=0.06u
MI9-M_u2 net55 net51 PG1 VDD pch w=0.35u l=0.06u
MI8-M_u2 net53 S0 PG1 VDD pch w=0.22u l=0.06u
MI16-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI4-M_u3 net33 net59 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net53 I0 VDD VDD pch w=0.35u l=0.06u
MI14-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MI6-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX3ND2 I0 I1 I2 S0 S1 ZN VDD VSS
MI22-M_u3 net53 net51 PG1 VSS nch w=0.23u l=0.06u
MI7-M_u3 net55 S0 PG1 VSS nch w=0.24u l=0.06u
MI9-M_u3 PG2 S1 net59 VSS nch w=0.32u l=0.06u
MI8-M_u3 PG1 net29 net59 VSS nch w=0.21u l=0.06u
MI3-M_u2 net33 net59 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 net53 I0 VSS VSS nch w=0.23u l=0.06u
MI6-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MU95-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI22-M_u2 net53 S0 PG1 VDD pch w=0.41u l=0.06u
MI7-M_u2 net55 net51 PG1 VDD pch w=0.35u l=0.06u
MI9-M_u2 PG2 net29 net59 VDD pch w=0.44u l=0.06u
MI8-M_u2 PG1 S1 net59 VDD pch w=0.26u l=0.06u
MI3-M_u3 net33 net59 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 net53 I0 VDD VDD pch w=0.34u l=0.06u
MI6-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net55 I1 VDD VDD pch w=0.53u l=0.06u
MU18_0-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MU95-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX3ND4 I0 I1 I2 S0 S1 ZN VDD VSS
MI5-M_u3 net53 net51 PG1 VSS nch w=0.32u l=0.06u
MI30-M_u3 net55 S0 PG1 VSS nch w=0.21u l=0.06u
MI32-M_u3 PG2 S1 net63 VSS nch w=0.21u l=0.06u
MI31-M_u3 PG1 net29 net63 VSS nch w=0.32u l=0.06u
MI8-M_u2 net33 net63 VSS VSS nch w=0.39u l=0.06u
MI21_0-M_u2 net53 I0 VSS VSS nch w=0.39u l=0.06u
MI21_1-M_u2 net53 I0 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net51 S0 VSS VSS nch w=0.195u l=0.06u
MI23_0-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MI23_1-M_u2 net55 I1 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI24_0-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MI24_1-M_u2 PG2 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net29 S1 VSS VSS nch w=0.195u l=0.06u
MI5-M_u2 net53 S0 PG1 VDD pch w=0.44u l=0.06u
MI30-M_u2 net55 net51 PG1 VDD pch w=0.34u l=0.06u
MI32-M_u2 PG2 net29 net63 VDD pch w=0.34u l=0.06u
MI31-M_u2 PG1 S1 net63 VDD pch w=0.44u l=0.06u
MI8-M_u3 net33 net63 VDD VDD pch w=0.52u l=0.06u
MI21_0-M_u3 net53 I0 VDD VDD pch w=0.52u l=0.06u
MI21_1-M_u3 net53 I0 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net51 S0 VDD VDD pch w=0.26u l=0.06u
MI23_0-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MI23_1-M_u3 net55 I1 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MI24_0-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MI24_1-M_u3 PG2 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net29 S1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX4D0 I0 I1 I2 I3 S0 S1 Z VDD VSS
MI46-M_u2 net72 I0 VSS VSS nch w=0.17u l=0.06u
MI47-M_u2 net66 I1 VSS VSS nch w=0.195u l=0.06u
MI48-M_u2 SN0 S0 VSS VSS nch w=0.18u l=0.06u
MI49-M_u2 net74 I2 VSS VSS nch w=0.18u l=0.06u
MI50-M_u2 net24 S1 VSS VSS nch w=0.15u l=0.06u
MI51-M_u2 net76 I3 VSS VSS nch w=0.195u l=0.06u
MU18-M_u2 Z net82 VSS VSS nch w=0.195u l=0.06u
MI53-M_u3 PG1 net24 net82 VSS nch w=0.195u l=0.06u
MI54-M_u3 net74 SN0 PG2 VSS nch w=0.18u l=0.06u
MI40-M_u3 net72 SN0 PG1 VSS nch w=0.17u l=0.06u
MI52-M_u3 net66 S0 PG1 VSS nch w=0.195u l=0.06u
MI55-M_u3 net76 S0 PG2 VSS nch w=0.195u l=0.06u
MI56-M_u3 PG2 S1 net82 VSS nch w=0.195u l=0.06u
MI46-M_u3 net72 I0 VDD VDD pch w=0.26u l=0.06u
MI47-M_u3 net66 I1 VDD VDD pch w=0.26u l=0.06u
MI48-M_u3 SN0 S0 VDD VDD pch w=0.26u l=0.06u
MI49-M_u3 net74 I2 VDD VDD pch w=0.26u l=0.06u
MI50-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MI51-M_u3 net76 I3 VDD VDD pch w=0.26u l=0.06u
MU18-M_u3 Z net82 VDD VDD pch w=0.26u l=0.06u
MI53-M_u2 PG1 S1 net82 VDD pch w=0.26u l=0.06u
MI54-M_u2 net74 S0 PG2 VDD pch w=0.26u l=0.06u
MI40-M_u2 net72 S0 PG1 VDD pch w=0.26u l=0.06u
MI52-M_u2 net66 SN0 PG1 VDD pch w=0.26u l=0.06u
MI55-M_u2 net76 SN0 PG2 VDD pch w=0.26u l=0.06u
MI56-M_u2 PG2 net24 net82 VDD pch w=0.26u l=0.06u
.ends
.subckt MUX4D1 I0 I1 I2 I3 S0 S1 Z VDD VSS
MI39-M_u2 net76 I3 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 net72 I0 VSS VSS nch w=0.18u l=0.06u
MI49-M_u2 net74 I2 VSS VSS nch w=0.19u l=0.06u
MI37-M_u2 net66 I1 VSS VSS nch w=0.39u l=0.06u
MI47-M_u2 net055 S0 VSS VSS nch w=0.18u l=0.06u
MI43-M_u2 net24 S1 VSS VSS nch w=0.195u l=0.06u
MU18-M_u2 Z net82 VSS VSS nch w=0.39u l=0.06u
MI53-M_u3 net079 S1 net82 VSS nch w=0.32u l=0.06u
MI54-M_u3 net071 net24 net82 VSS nch w=0.18u l=0.06u
MI50-M_u3 net66 S0 net071 VSS nch w=0.28u l=0.06u
MI46-M_u3 net72 net055 net071 VSS nch w=0.18u l=0.06u
MI52-M_u3 net76 S0 net079 VSS nch w=0.225u l=0.06u
MI51-M_u3 net74 net055 net079 VSS nch w=0.19u l=0.06u
MI39-M_u3 net76 I3 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 net72 I0 VDD VDD pch w=0.34u l=0.06u
MI49-M_u3 net74 I2 VDD VDD pch w=0.34u l=0.06u
MI37-M_u3 net66 I1 VDD VDD pch w=0.52u l=0.06u
MI47-M_u3 net055 S0 VDD VDD pch w=0.26u l=0.06u
MI43-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MU18-M_u3 Z net82 VDD VDD pch w=0.52u l=0.06u
MI53-M_u2 net079 net24 net82 VDD pch w=0.31u l=0.06u
MI54-M_u2 net071 S1 net82 VDD pch w=0.31u l=0.06u
MI50-M_u2 net66 net055 net071 VDD pch w=0.35u l=0.06u
MI46-M_u2 net72 S0 net071 VDD pch w=0.35u l=0.06u
MI52-M_u2 net76 net055 net079 VDD pch w=0.45u l=0.06u
MI51-M_u2 net74 S0 net079 VDD pch w=0.405u l=0.06u
.ends
.subckt MUX4D2 I0 I1 I2 I3 S0 S1 Z VDD VSS
MI53-M_u3 PG1 net24 net77 VSS nch w=0.41u l=0.06u
MI52-M_u3 net66 S0 PG1 VSS nch w=0.19u l=0.06u
MI51-M_u3 net72 net055 PG1 VSS nch w=0.19u l=0.06u
MI54-M_u3 net74 net055 PG2 VSS nch w=0.19u l=0.06u
MI56-M_u3 net76 S0 PG2 VSS nch w=0.245u l=0.06u
MI55-M_u3 PG2 S1 net77 VSS nch w=0.26u l=0.06u
MI50-M_u2 net74 I2 VSS VSS nch w=0.78u l=0.06u
MI34-M_u2 net76 I3 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 net66 I1 VSS VSS nch w=0.78u l=0.06u
MI49-M_u2 net72 I0 VSS VSS nch w=0.78u l=0.06u
MI42-M_u2 net24 S1 VSS VSS nch w=0.195u l=0.06u
MI48-M_u2 net055 S0 VSS VSS nch w=0.195u l=0.06u
MU18_0-M_u2 Z net77 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z net77 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 PG1 S1 net77 VDD pch w=0.37u l=0.06u
MI52-M_u2 net66 net055 PG1 VDD pch w=0.26u l=0.06u
MI51-M_u2 net72 S0 PG1 VDD pch w=0.26u l=0.06u
MI54-M_u2 net74 S0 PG2 VDD pch w=0.26u l=0.06u
MI56-M_u2 net76 net055 PG2 VDD pch w=0.26u l=0.06u
MI55-M_u2 PG2 net24 net77 VDD pch w=0.34u l=0.06u
MI50-M_u3 net74 I2 VDD VDD pch w=1.04u l=0.06u
MI34-M_u3 net76 I3 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 net66 I1 VDD VDD pch w=1.04u l=0.06u
MI49-M_u3 net72 I0 VDD VDD pch w=1.04u l=0.06u
MI42-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MI48-M_u3 net055 S0 VDD VDD pch w=0.26u l=0.06u
MU18_0-M_u3 Z net77 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z net77 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MUX4D4 I0 I1 I2 I3 S0 S1 Z VDD VSS
MI57-M_u3 net67 SN0 PG2 VSS nch w=0.19u l=0.06u
MI50-M_u3 net79 SN0 PG1 VSS nch w=0.19u l=0.06u
MI56-M_u3 PG1 net54 p0 VSS nch w=0.41u l=0.06u
MI55-M_u3 net75 S0 PG1 VSS nch w=0.19u l=0.06u
MI58-M_u3 PG2 S1 p0 VSS nch w=0.26u l=0.06u
MI59-M_u3 net71 S0 PG2 VSS nch w=0.245u l=0.06u
MI44_0-M_u2 net71 I3 VSS VSS nch w=0.39u l=0.06u
MI44_1-M_u2 net71 I3 VSS VSS nch w=0.39u l=0.06u
MI41_0-M_u2 net79 I0 VSS VSS nch w=0.39u l=0.06u
MI41_1-M_u2 net79 I0 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 net75 I1 VSS VSS nch w=0.39u l=0.06u
MI42_1-M_u2 net75 I1 VSS VSS nch w=0.39u l=0.06u
MI43_0-M_u2 net67 I2 VSS VSS nch w=0.39u l=0.06u
MI43_1-M_u2 net67 I2 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net54 S1 VSS VSS nch w=0.195u l=0.06u
MI60-M_u2 SN0 S0 VSS VSS nch w=0.195u l=0.06u
MU18_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 net67 S0 PG2 VDD pch w=0.26u l=0.06u
MI50-M_u2 net79 S0 PG1 VDD pch w=0.26u l=0.06u
MI56-M_u2 PG1 S1 p0 VDD pch w=0.37u l=0.06u
MI55-M_u2 net75 SN0 PG1 VDD pch w=0.26u l=0.06u
MI58-M_u2 PG2 net54 p0 VDD pch w=0.34u l=0.06u
MI59-M_u2 net71 SN0 PG2 VDD pch w=0.26u l=0.06u
MI44_0-M_u3 net71 I3 VDD VDD pch w=0.52u l=0.06u
MI44_1-M_u3 net71 I3 VDD VDD pch w=0.52u l=0.06u
MI41_0-M_u3 net79 I0 VDD VDD pch w=0.52u l=0.06u
MI41_1-M_u3 net79 I0 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 net75 I1 VDD VDD pch w=0.52u l=0.06u
MI42_1-M_u3 net75 I1 VDD VDD pch w=0.52u l=0.06u
MI43_0-M_u3 net67 I2 VDD VDD pch w=0.52u l=0.06u
MI43_1-M_u3 net67 I2 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net54 S1 VDD VDD pch w=0.26u l=0.06u
MI60-M_u3 SN0 S0 VDD VDD pch w=0.26u l=0.06u
MU18_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MUX4ND0 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MU18-M_u2 net24 S1 VSS VSS nch w=0.195u l=0.06u
MI47-M_u2 net74 I2 VSS VSS nch w=0.19u l=0.06u
MI55-M_u2 net72 I0 VSS VSS nch w=0.2u l=0.06u
MI57-M_u2 net76 I3 VSS VSS nch w=0.39u l=0.06u
MI58-M_u2 net044 S0 VSS VSS nch w=0.18u l=0.06u
MI56-M_u2 net052 I1 VSS VSS nch w=0.39u l=0.06u
MI51-M_u3 PG2 S1 ZN VSS nch w=0.195u l=0.06u
MI52-M_u3 net74 net044 PG2 VSS nch w=0.19u l=0.06u
MI49-M_u3 net052 S0 PG1 VSS nch w=0.195u l=0.06u
MI50-M_u3 PG1 net24 ZN VSS nch w=0.195u l=0.06u
MI54-M_u3 net76 S0 PG2 VSS nch w=0.195u l=0.06u
MI48-M_u3 net72 net044 PG1 VSS nch w=0.19u l=0.06u
MU18-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MI47-M_u3 net74 I2 VDD VDD pch w=0.34u l=0.06u
MI55-M_u3 net72 I0 VDD VDD pch w=0.34u l=0.06u
MI57-M_u3 net76 I3 VDD VDD pch w=0.52u l=0.06u
MI58-M_u3 net044 S0 VDD VDD pch w=0.26u l=0.06u
MI56-M_u3 net052 I1 VDD VDD pch w=0.52u l=0.06u
MI51-M_u2 PG2 net24 ZN VDD pch w=0.26u l=0.06u
MI52-M_u2 net74 S0 PG2 VDD pch w=0.26u l=0.06u
MI49-M_u2 net052 net044 PG1 VDD pch w=0.26u l=0.06u
MI50-M_u2 PG1 S1 ZN VDD pch w=0.26u l=0.06u
MI54-M_u2 net76 net044 PG2 VDD pch w=0.26u l=0.06u
MI48-M_u2 net72 S0 PG1 VDD pch w=0.26u l=0.06u
.ends
.subckt MUX4ND1 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MI43-M_u3 PG1 net24 net59 VSS nch w=0.23u l=0.06u
MI44-M_u3 net74 SN0 net070 VSS nch w=0.19u l=0.06u
MI42-M_u3 net66 S0 net074 VSS nch w=0.245u l=0.06u
MI50-M_u3 net72 SN0 net074 VSS nch w=0.19u l=0.06u
MI45-M_u3 net76 S0 net070 VSS nch w=0.245u l=0.06u
MI46-M_u3 PG2 S1 net59 VSS nch w=0.375u l=0.06u
MI37-M_u2 PG1 net074 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 PG2 net070 VSS VSS nch w=0.355u l=0.06u
MI34-M_u2 net76 I3 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 net72 I0 VSS VSS nch w=0.19u l=0.06u
MI36-M_u2 ZN net59 VSS VSS nch w=0.39u l=0.06u
MI40-M_u2 net66 I1 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 net74 I2 VSS VSS nch w=0.19u l=0.06u
MU19-M_u2 net24 S1 VSS VSS nch w=0.195u l=0.06u
MI47-M_u2 SN0 S0 VSS VSS nch w=0.18u l=0.06u
MI43-M_u2 PG1 S1 net59 VDD pch w=0.315u l=0.06u
MI44-M_u2 net74 S0 net070 VDD pch w=0.405u l=0.06u
MI42-M_u2 net66 SN0 net074 VDD pch w=0.45u l=0.06u
MI50-M_u2 net72 S0 net074 VDD pch w=0.405u l=0.06u
MI45-M_u2 net76 SN0 net070 VDD pch w=0.45u l=0.06u
MI46-M_u2 PG2 net24 net59 VDD pch w=0.45u l=0.06u
MI37-M_u3 PG1 net074 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 PG2 net070 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net76 I3 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 net72 I0 VDD VDD pch w=0.34u l=0.06u
MI36-M_u3 ZN net59 VDD VDD pch w=0.52u l=0.06u
MI40-M_u3 net66 I1 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 net74 I2 VDD VDD pch w=0.34u l=0.06u
MU19-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MI47-M_u3 SN0 S0 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt MUX4ND2 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MI46-M_u3 net74 SN0 net0127 VSS nch w=0.19u l=0.06u
MI47-M_u3 net76 S0 net0127 VSS nch w=0.245u l=0.06u
MI45-M_u3 net66 S0 net0131 VSS nch w=0.245u l=0.06u
MI54-M_u3 net72 SN0 net0131 VSS nch w=0.19u l=0.06u
MI48-M_u3 PG2 S1 net77 VSS nch w=0.355u l=0.06u
MI49-M_u3 PG1 net24 net77 VSS nch w=0.23u l=0.06u
MI37-M_u2 PG1 net0131 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 PG2 net0127 VSS VSS nch w=0.355u l=0.06u
MI41-M_u2 net76 I3 VSS VSS nch w=0.39u l=0.06u
MI43-M_u2 net72 I0 VSS VSS nch w=0.19u l=0.06u
MI39-M_u2 net66 I1 VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 net74 I2 VSS VSS nch w=0.19u l=0.06u
MU19-M_u2 net24 S1 VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 SN0 S0 VSS VSS nch w=0.18u l=0.06u
MU18_0-M_u2 ZN net77 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net77 VSS VSS nch w=0.39u l=0.06u
MI46-M_u2 net74 S0 net0127 VDD pch w=0.405u l=0.06u
MI47-M_u2 net76 SN0 net0127 VDD pch w=0.45u l=0.06u
MI45-M_u2 net66 SN0 net0131 VDD pch w=0.45u l=0.06u
MI54-M_u2 net72 S0 net0131 VDD pch w=0.405u l=0.06u
MI48-M_u2 PG2 net24 net77 VDD pch w=0.45u l=0.06u
MI49-M_u2 PG1 S1 net77 VDD pch w=0.315u l=0.06u
MI37-M_u3 PG1 net0131 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 PG2 net0127 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 net76 I3 VDD VDD pch w=0.52u l=0.06u
MI43-M_u3 net72 I0 VDD VDD pch w=0.34u l=0.06u
MI39-M_u3 net66 I1 VDD VDD pch w=0.52u l=0.06u
MI44-M_u3 net74 I2 VDD VDD pch w=0.34u l=0.06u
MU19-M_u3 net24 S1 VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 SN0 S0 VDD VDD pch w=0.26u l=0.06u
MU18_0-M_u3 ZN net77 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net77 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt MUX4ND4 I0 I1 I2 I3 S0 S1 ZN VDD VSS
MI41_0-M_u2 PG1 net073 VSS VSS nch w=0.39u l=0.06u
MI41_1-M_u2 PG1 net073 VSS VSS nch w=0.39u l=0.06u
MI46_0-M_u2 net70 I3 VSS VSS nch w=0.39u l=0.06u
MI46_1-M_u2 net70 I3 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 PG2 net069 VSS VSS nch w=0.39u l=0.06u
MI42_1-M_u2 PG2 net069 VSS VSS nch w=0.39u l=0.06u
MI45_0-M_u2 net66 I2 VSS VSS nch w=0.2u l=0.06u
MI45_1-M_u2 net66 I2 VSS VSS nch w=0.2u l=0.06u
MI43_0-M_u2 net78 I0 VSS VSS nch w=0.225u l=0.06u
MI43_1-M_u2 net78 I0 VSS VSS nch w=0.23u l=0.06u
MI44_0-M_u2 net74 I1 VSS VSS nch w=0.39u l=0.06u
MI44_1-M_u2 net74 I1 VSS VSS nch w=0.39u l=0.06u
MU19-M_u2 net57 S1 VSS VSS nch w=0.39u l=0.06u
MU26-M_u2 net062 S0 VSS VSS nch w=0.195u l=0.06u
MU18_0-M_u2 ZN net81 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 ZN net81 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 ZN net81 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 ZN net81 VSS VSS nch w=0.39u l=0.06u
MI54-M_u3 net78 net062 net073 VSS nch w=0.19u l=0.06u
MI52-M_u3 net70 S0 net069 VSS nch w=0.245u l=0.06u
MI50-M_u3 net74 S0 net073 VSS nch w=0.245u l=0.06u
MI51-M_u3 net66 net062 net069 VSS nch w=0.19u l=0.06u
MI55-M_u3 PG2 S1 net81 VSS nch w=0.32u l=0.06u
MI53-M_u3 PG1 net57 net81 VSS nch w=0.21u l=0.06u
MI41_0-M_u3 PG1 net073 VDD VDD pch w=0.52u l=0.06u
MI41_1-M_u3 PG1 net073 VDD VDD pch w=0.52u l=0.06u
MI46_0-M_u3 net70 I3 VDD VDD pch w=0.52u l=0.06u
MI46_1-M_u3 net70 I3 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 PG2 net069 VDD VDD pch w=0.52u l=0.06u
MI42_1-M_u3 PG2 net069 VDD VDD pch w=0.52u l=0.06u
MI45_0-M_u3 net66 I2 VDD VDD pch w=0.34u l=0.06u
MI45_1-M_u3 net66 I2 VDD VDD pch w=0.34u l=0.06u
MI43_0-M_u3 net78 I0 VDD VDD pch w=0.28u l=0.06u
MI43_1-M_u3 net78 I0 VDD VDD pch w=0.28u l=0.06u
MI44_0-M_u3 net74 I1 VDD VDD pch w=0.52u l=0.06u
MI44_1-M_u3 net74 I1 VDD VDD pch w=0.52u l=0.06u
MU19-M_u3 net57 S1 VDD VDD pch w=0.52u l=0.06u
MU26-M_u3 net062 S0 VDD VDD pch w=0.26u l=0.06u
MU18_0-M_u3 ZN net81 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 ZN net81 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 ZN net81 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 ZN net81 VDD VDD pch w=0.52u l=0.06u
MI54-M_u2 net78 S0 net073 VDD pch w=0.42u l=0.06u
MI52-M_u2 net70 net062 net069 VDD pch w=0.45u l=0.06u
MI50-M_u2 net74 net062 net073 VDD pch w=0.45u l=0.06u
MI51-M_u2 net66 S0 net069 VDD pch w=0.405u l=0.06u
MI55-M_u2 PG2 net57 net81 VDD pch w=0.45u l=0.06u
MI53-M_u2 PG1 S1 net81 VDD pch w=0.315u l=0.06u
.ends
.subckt ND2D0 A1 A2 ZN VDD VSS
MI0-M_u4 XI0-net6 A2 VSS VSS nch w=0.195u l=0.06u
MI0-M_u3 ZN A1 XI0-net6 VSS nch w=0.195u l=0.06u
MI0-M_u2 ZN A2 VDD VDD pch w=0.26u l=0.06u
MI0-M_u1 ZN A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt ND2D1 A1 A2 ZN VDD VSS
MI1-M_u4 XI1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 ZN A1 XI1-net6 VSS nch w=0.39u l=0.06u
MI1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND2D2 A1 A2 ZN VDD VSS
MU3_0-M_u4 XU3_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU3_0-M_u3 ZN A1 XU3_0-net6 VSS nch w=0.39u l=0.06u
MU3_1-M_u4 XU3_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU3_1-M_u3 ZN A1 XU3_1-net6 VSS nch w=0.39u l=0.06u
MU3_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MU3_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MU3_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MU3_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND2D3 A1 A2 ZN VDD VSS
MU3_0-M_u4 XU3_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU3_0-M_u3 ZN A1 XU3_0-net6 VSS nch w=0.39u l=0.06u
MU3_1-M_u4 XU3_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU3_1-M_u3 ZN A1 XU3_1-net6 VSS nch w=0.39u l=0.06u
MU3_2-M_u4 XU3_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
MU3_2-M_u3 ZN A1 XU3_2-net6 VSS nch w=0.39u l=0.06u
MU3_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MU3_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MU3_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MU3_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MU3_2-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MU3_2-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND2D4 A1 A2 ZN VDD VSS
MI1_0-M_u4 XI1_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1_0-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1_1-net6 VSS nch w=0.39u l=0.06u
MI1_2-M_u4 XI1_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A1 XI1_2-net6 VSS nch w=0.39u l=0.06u
MI1_3-M_u4 XI1_3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_3-M_u3 ZN A1 XI1_3-net6 VSS nch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_3-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_3-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND2D8 A1 A2 ZN VDD VSS
MI36 net026 A2 VSS VSS nch w=0.23u l=0.06u
MI35 ZN A1 net026 VSS nch w=0.23u l=0.06u
MI20 net032 A2 VSS VSS nch w=0.39u l=0.06u
MI17 ZN A1 net032 VSS nch w=0.39u l=0.06u
MI21 net031 A2 VSS VSS nch w=0.39u l=0.06u
MI23 ZN A1 net050 VSS nch w=0.39u l=0.06u
MI22 ZN A1 net031 VSS nch w=0.39u l=0.06u
MI26 ZN A1 net053 VSS nch w=0.39u l=0.06u
MI19 ZN A1 net071 VSS nch w=0.39u l=0.06u
MI24 net050 A2 VSS VSS nch w=0.39u l=0.06u
MI25 net053 A2 VSS VSS nch w=0.39u l=0.06u
MI27 ZN A1 net059 VSS nch w=0.39u l=0.06u
MI28 net059 A2 VSS VSS nch w=0.39u l=0.06u
MI29 net062 A2 VSS VSS nch w=0.23u l=0.06u
MI18 net071 A2 VSS VSS nch w=0.39u l=0.06u
MI30 ZN A1 net062 VSS nch w=0.23u l=0.06u
M_u2_0 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_1 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_2 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_3 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_4 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_5 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_6 ZN A2 VDD VDD pch w=0.52u l=0.06u
M_u2_7 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI6_0 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_2 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_3 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_4 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_5 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_6 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI6_7 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND3D0 A1 A2 A3 ZN VDD VSS
MI0-M_u4 ZN A1 XI0-net10 VSS nch w=0.195u l=0.06u
MI0-M_u5 XI0-net10 A2 XI0-net13 VSS nch w=0.195u l=0.06u
MI0-M_u6 XI0-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI0-M_u3 ZN A3 VDD VDD pch w=0.26u l=0.06u
MI0-M_u1 ZN A1 VDD VDD pch w=0.26u l=0.06u
MI0-M_u2 ZN A2 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt ND3D1 A1 A2 A3 ZN VDD VSS
MI1-M_u4 ZN A1 XI1-net10 VSS nch w=0.39u l=0.06u
MI1-M_u5 XI1-net10 A2 XI1-net13 VSS nch w=0.39u l=0.06u
MI1-M_u6 XI1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND3D2 A1 A2 A3 ZN VDD VSS
MI0_0-M_u4 ZN A1 XI0_0-net10 VSS nch w=0.39u l=0.06u
MI0_0-M_u5 XI0_0-net10 A2 XI0_0-net13 VSS nch w=0.39u l=0.06u
MI0_0-M_u6 XI0_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI0_1-M_u4 ZN A1 XI0_1-net10 VSS nch w=0.39u l=0.06u
MI0_1-M_u5 XI0_1-net10 A2 XI0_1-net13 VSS nch w=0.39u l=0.06u
MI0_1-M_u6 XI0_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI0_0-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI0_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND3D3 A1 A2 A3 ZN VDD VSS
MI0_0-M_u4 ZN A1 XI0_0-net10 VSS nch w=0.39u l=0.06u
MI0_0-M_u5 XI0_0-net10 A2 XI0_0-net13 VSS nch w=0.39u l=0.06u
MI0_0-M_u6 XI0_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI0_1-M_u4 ZN A1 XI0_1-net10 VSS nch w=0.39u l=0.06u
MI0_1-M_u5 XI0_1-net10 A2 XI0_1-net13 VSS nch w=0.39u l=0.06u
MI0_1-M_u6 XI0_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI0_2-M_u4 ZN A1 XI0_2-net10 VSS nch w=0.39u l=0.06u
MI0_2-M_u5 XI0_2-net10 A2 XI0_2-net13 VSS nch w=0.39u l=0.06u
MI0_2-M_u6 XI0_2-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI0_0-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI0_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI0_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI0_2-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0_2-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI0_2-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND3D4 A1 A2 A3 ZN VDD VSS
MI7 VDD A1 ZN VDD pch w=2.06u l=0.06u
MI6 VDD A2 ZN VDD pch w=2.06u l=0.06u
MI4 VDD A3 ZN VDD pch w=2.06u l=0.06u
MI12_0 ZN A1 net24<0> VSS nch w=0.39u l=0.06u
MI12_1 ZN A1 net24<1> VSS nch w=0.39u l=0.06u
MI12_2 ZN A1 net24<2> VSS nch w=0.39u l=0.06u
MI12_3 ZN A1 net24<3> VSS nch w=0.39u l=0.06u
MI5_0 net21<0> A3 VSS VSS nch w=0.39u l=0.06u
MI5_1 net21<1> A3 VSS VSS nch w=0.39u l=0.06u
MI5_2 net21<2> A3 VSS VSS nch w=0.39u l=0.06u
MI5_3 net21<3> A3 VSS VSS nch w=0.39u l=0.06u
MI2_0 net24<0> A2 net21<0> VSS nch w=0.39u l=0.06u
MI2_1 net24<1> A2 net21<1> VSS nch w=0.39u l=0.06u
MI2_2 net24<2> A2 net21<2> VSS nch w=0.39u l=0.06u
MI2_3 net24<3> A2 net21<3> VSS nch w=0.39u l=0.06u
.ends
.subckt ND3D8 A1 A2 A3 ZN VDD VSS
MI0-M_u4 ZN A1 XI0-net10 VSS nch w=3.12u l=0.06u
MI0-M_u5 XI0-net10 A2 XI0-net13 VSS nch w=3.12u l=0.06u
MI0-M_u6 XI0-net13 A3 VSS VSS nch w=3.12u l=0.06u
MI0-M_u3 ZN A3 VDD VDD pch w=4.16u l=0.06u
MI0-M_u1 ZN A1 VDD VDD pch w=4.16u l=0.06u
MI0-M_u2 ZN A2 VDD VDD pch w=4.16u l=0.06u
.ends
.subckt ND4D0 A1 A2 A3 A4 ZN VDD VSS
MI19 p2 A4 VSS VSS nch w=0.195u l=0.06u
MI17 p0 A2 p1 VSS nch w=0.195u l=0.06u
MI18 p1 A3 p2 VSS nch w=0.195u l=0.06u
MU53 ZN A1 p0 VSS nch w=0.195u l=0.06u
MI14 ZN A3 VDD VDD pch w=0.26u l=0.06u
MI15 ZN A2 VDD VDD pch w=0.26u l=0.06u
MI16 ZN A1 VDD VDD pch w=0.26u l=0.06u
MI9 ZN A4 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt ND4D1 A1 A2 A3 A4 ZN VDD VSS
MI5 p2 A4 VSS VSS nch w=0.39u l=0.06u
MI3 p0 A2 p1 VSS nch w=0.39u l=0.06u
MI4 p1 A3 p2 VSS nch w=0.39u l=0.06u
MU53 ZN A1 p0 VSS nch w=0.39u l=0.06u
MI7 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI1 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI0 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND4D2 A1 A2 A3 A4 ZN VDD VSS
MI12_0 p2 A4 VSS VSS nch w=0.39u l=0.06u
MI12_1 p2 A4 VSS VSS nch w=0.39u l=0.06u
MI9_0 p0 A2 p1 VSS nch w=0.39u l=0.06u
MI9_1 p0 A2 p1 VSS nch w=0.39u l=0.06u
MI11_0 p1 A3 p2 VSS nch w=0.39u l=0.06u
MI11_1 p1 A3 p2 VSS nch w=0.39u l=0.06u
MU53_0 ZN A1 p0 VSS nch w=0.39u l=0.06u
MU53_1 ZN A1 p0 VSS nch w=0.39u l=0.06u
MI8_0 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI8_1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2_0 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI2_1 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI6_0 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI6_1 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI7_0 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI7_1 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND4D3 A1 A2 A3 A4 ZN VDD VSS
MI28 net026 A3 net023 VSS nch w=1.17u l=0.06u
MI29 net023 A4 VSS VSS nch w=1.17u l=0.06u
MI27 net029 A2 net026 VSS nch w=1.17u l=0.06u
MU53 ZN A1 net029 VSS nch w=1.17u l=0.06u
MI8_0 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI8_1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI8_2 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2_0 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI2_1 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI2_2 ZN A4 VDD VDD pch w=0.52u l=0.06u
MI6_0 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI6_1 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI6_2 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI7_0 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI7_1 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI7_2 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ND4D4 A1 A2 A3 A4 ZN VDD VSS
MU3-M_u5 ZN A1 XU3-net23 VSS nch w=1.56u l=0.06u
MU3-MI0 XU3-net23 A2 XU3-net26 VSS nch w=1.56u l=0.06u
MU3-MI1 XU3-net26 A3 XU3-net29 VSS nch w=1.56u l=0.06u
MU3-MI2 XU3-net29 A4 VSS VSS nch w=1.56u l=0.06u
MU3-M_u4 ZN A4 VDD VDD pch w=2.08u l=0.06u
MU3-M_u3 ZN A3 VDD VDD pch w=2.08u l=0.06u
MU3-M_u2 ZN A2 VDD VDD pch w=2.08u l=0.06u
MU3-M_u1 ZN A1 VDD VDD pch w=2.08u l=0.06u
.ends
.subckt ND4D8 A1 A2 A3 A4 ZN VDD VSS
MI4_0-M_u2 n0 net17 VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 n0 net17 VSS VSS nch w=0.39u l=0.06u
MI4_2-M_u2 n0 net17 VSS VSS nch w=0.39u l=0.06u
MI9_0-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_1-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_2-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_3-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_4-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_5-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_6-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI9_7-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MU3-M_u5 net17 A1 XU3-net23 VSS nch w=0.39u l=0.06u
MU3-MI0 XU3-net23 A2 XU3-net26 VSS nch w=0.39u l=0.06u
MU3-MI1 XU3-net26 A3 XU3-net29 VSS nch w=0.39u l=0.06u
MU3-MI2 XU3-net29 A4 VSS VSS nch w=0.39u l=0.06u
MI4_0-M_u3 n0 net17 VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 n0 net17 VDD VDD pch w=0.52u l=0.06u
MI4_2-M_u3 n0 net17 VDD VDD pch w=0.52u l=0.06u
MI9_0-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_1-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_2-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_3-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_4-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_5-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_6-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI9_7-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MU3-M_u4 net17 A4 VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net17 A3 VDD VDD pch w=0.52u l=0.06u
MU3-M_u2 net17 A2 VDD VDD pch w=0.52u l=0.06u
MU3-M_u1 net17 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt NR2D0 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=0.195u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=0.26u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=0.26u l=0.06u
.ends
.subckt NR2D1 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt NR2D2 A1 A2 ZN VDD VSS
MI1_0-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u1 XI1_0-net8 A2 VDD VDD pch w=0.53u l=0.06u
MI1_0-M_u2 ZN A1 XI1_0-net8 VDD pch w=0.53u l=0.06u
MI1_1-M_u1 XI1_1-net8 A2 VDD VDD pch w=0.53u l=0.06u
MI1_1-M_u2 ZN A1 XI1_1-net8 VDD pch w=0.53u l=0.06u
.ends
.subckt NR2D3 A1 A2 ZN VDD VSS
MI1_0-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u1 XI1_0-net8 A2 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u2 ZN A1 XI1_0-net8 VDD pch w=0.52u l=0.06u
MI1_1-M_u1 XI1_1-net8 A2 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u2 ZN A1 XI1_1-net8 VDD pch w=0.52u l=0.06u
MI1_2-M_u1 XI1_2-net8 A2 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u2 ZN A1 XI1_2-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt NR2D4 A1 A2 ZN VDD VSS
MI6_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_2 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI5_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI5_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI5_2 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI5_3 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI27_0 net024<0> A2 VDD VDD pch w=0.52u l=0.06u
MI27_1 net024<1> A2 VDD VDD pch w=0.52u l=0.06u
MI27_2 net024<2> A2 VDD VDD pch w=0.52u l=0.06u
MI27_3 net024<3> A2 VDD VDD pch w=0.52u l=0.06u
MI28_0 ZN A1 net024<0> VDD pch w=0.52u l=0.06u
MI28_1 ZN A1 net024<1> VDD pch w=0.52u l=0.06u
MI28_2 ZN A1 net024<2> VDD pch w=0.52u l=0.06u
MI28_3 ZN A1 net024<3> VDD pch w=0.52u l=0.06u
.ends
.subckt NR2D8 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=3.12u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=3.12u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=4.16u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=4.16u l=0.06u
.ends
.subckt NR2XD0 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=0.195u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt NR2XD1 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=1.04u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=1.04u l=0.06u
.ends
.subckt NR2XD2 A1 A2 ZN VDD VSS
MI2-M_u4 ZN A1 VSS VSS nch w=0.78u l=0.06u
MI2-M_u3 ZN A2 VSS VSS nch w=0.78u l=0.06u
MI2-M_u1 XI2-net8 A2 VDD VDD pch w=2.08u l=0.06u
MI2-M_u2 ZN A1 XI2-net8 VDD pch w=2.08u l=0.06u
.ends
.subckt NR2XD3 A1 A2 ZN VDD VSS
MI2-M_u4 ZN A1 VSS VSS nch w=1.17u l=0.06u
MI2-M_u3 ZN A2 VSS VSS nch w=1.17u l=0.06u
MI2-M_u1 XI2-net8 A2 VDD VDD pch w=3.12u l=0.06u
MI2-M_u2 ZN A1 XI2-net8 VDD pch w=3.12u l=0.06u
.ends
.subckt NR2XD4 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=1.56u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=1.56u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=4.16u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=4.16u l=0.06u
.ends
.subckt NR2XD8 A1 A2 ZN VDD VSS
MI1-M_u4 ZN A1 VSS VSS nch w=3.12u l=0.06u
MI1-M_u3 ZN A2 VSS VSS nch w=3.12u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=8.32u l=0.06u
MI1-M_u2 ZN A1 XI1-net8 VDD pch w=8.32u l=0.06u
.ends
.subckt NR3D0 A1 A2 A3 ZN VDD VSS
M_u4 ZN A3 VSS VSS nch w=0.195u l=0.06u
MI2 ZN A2 VSS VSS nch w=0.195u l=0.06u
MI3 ZN A1 VSS VSS nch w=0.195u l=0.06u
M_u1 net25 A3 VDD VDD pch w=0.52u l=0.06u
MI0 net28 A2 net25 VDD pch w=0.52u l=0.06u
MI1 ZN A1 net28 VDD pch w=0.52u l=0.06u
.ends
.subckt NR3D1 A1 A2 A3 ZN VDD VSS
M_u4 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI2 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI3 ZN A1 VSS VSS nch w=0.39u l=0.06u
M_u1_0 net47<0> A3 VDD VDD pch w=0.52u l=0.06u
M_u1_1 net47<1> A3 VDD VDD pch w=0.52u l=0.06u
MI0_0 net44<0> A2 net47<0> VDD pch w=0.52u l=0.06u
MI0_1 net44<1> A2 net47<1> VDD pch w=0.52u l=0.06u
MI1_0 ZN A1 net44<0> VDD pch w=0.52u l=0.06u
MI1_1 ZN A1 net44<1> VDD pch w=0.52u l=0.06u
.ends
.subckt NR3D2 A1 A2 A3 ZN VDD VSS
M_u4_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI7_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI6_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
M_u1 net034 A3 VDD VDD pch w=2.01u l=0.06u
MI25 ZN A1 net031 VDD pch w=2.01u l=0.06u
MI24 net031 A2 net034 VDD pch w=2.01u l=0.06u
.ends
.subckt NR3D3 A1 A2 A3 ZN VDD VSS
MI0-M_u6 ZN A1 VSS VSS nch w=1.17u l=0.06u
MI0-M_u5 ZN A2 VSS VSS nch w=1.17u l=0.06u
MI0-M_u4 ZN A3 VSS VSS nch w=1.17u l=0.06u
MI0-M_u1 XI0-net9 A3 VDD VDD pch w=3.12u l=0.06u
MI0-M_u2 XI0-net12 A2 XI0-net9 VDD pch w=3.12u l=0.06u
MI0-M_u3 ZN A1 XI0-net12 VDD pch w=3.12u l=0.06u
.ends
.subckt NR3D4 A1 A2 A3 ZN VDD VSS
MI0-M_u6 ZN A1 VSS VSS nch w=1.56u l=0.06u
MI0-M_u5 ZN A2 VSS VSS nch w=1.56u l=0.06u
MI0-M_u4 ZN A3 VSS VSS nch w=1.56u l=0.06u
MI0-M_u1 XI0-net9 A3 VDD VDD pch w=4.02u l=0.06u
MI0-M_u2 XI0-net12 A2 XI0-net9 VDD pch w=4.02u l=0.06u
MI0-M_u3 ZN A1 XI0-net12 VDD pch w=4.02u l=0.06u
.ends
.subckt NR3D8 A1 A2 A3 ZN VDD VSS
M_u4_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_2 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_3 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_4 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_5 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_6 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_7 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI7_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_2 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_3 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_4 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_5 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_6 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_7 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI6_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_2 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_3 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_4 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_5 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_6 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_7 ZN A2 VSS VSS nch w=0.39u l=0.06u
M_u1 net034 A3 VDD VDD pch w=8.04u l=0.06u
MI52 net031 A2 net034 VDD pch w=8.04u l=0.06u
MI53 ZN A1 net031 VDD pch w=8.04u l=0.06u
.ends
.subckt NR4D0 A1 A2 A3 A4 ZN VDD VSS
MI36 ZN A4 VSS VSS nch w=0.195u l=0.06u
MI35 ZN A3 VSS VSS nch w=0.195u l=0.06u
MI34 ZN A2 VSS VSS nch w=0.195u l=0.06u
MI5 ZN A1 VSS VSS nch w=0.195u l=0.06u
MI26 net49 A3 net52 VDD pch w=0.52u l=0.06u
MI7 net52 A4 VDD VDD pch w=0.52u l=0.06u
MI27 net46 A2 net49 VDD pch w=0.52u l=0.06u
MI28 ZN A1 net46 VDD pch w=0.52u l=0.06u
.ends
.subckt NR4D1 A1 A2 A3 A4 ZN VDD VSS
MI39 ZN A4 VSS VSS nch w=0.21u l=0.06u
MI38 ZN A3 VSS VSS nch w=0.23u l=0.06u
MI37 ZN A2 VSS VSS nch w=0.23u l=0.06u
MI5 ZN A1 VSS VSS nch w=0.21u l=0.06u
MI26 net49 A3 net52 VDD pch w=0.52u l=0.06u
MI30 net43 A2 net40 VDD pch w=0.52u l=0.06u
MI31 net40 A3 net37 VDD pch w=0.52u l=0.06u
MI32 net37 A4 VDD VDD pch w=0.52u l=0.06u
MI29 ZN A1 net43 VDD pch w=0.52u l=0.06u
MI7 net52 A4 VDD VDD pch w=0.52u l=0.06u
MI27 net46 A2 net49 VDD pch w=0.52u l=0.06u
MI28 ZN A1 net46 VDD pch w=0.52u l=0.06u
.ends
.subckt NR4D2 A1 A2 A3 A4 ZN VDD VSS
MI45_0 ZN A4 VSS VSS nch w=0.39u l=0.06u
MI45_1 ZN A4 VSS VSS nch w=0.39u l=0.06u
MI44_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI44_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI43_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI43_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI5_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI5_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI52 p1 A3 p0 VDD pch w=2.01u l=0.06u
MI7 p0 A4 VDD VDD pch w=2.01u l=0.06u
MI53 p2 A2 p1 VDD pch w=2.01u l=0.06u
MI54 ZN A1 p2 VDD pch w=2.01u l=0.06u
.ends
.subckt NR4D3 A1 A2 A3 A4 ZN VDD VSS
MI48_0 ZN A4 VSS VSS nch w=0.39u l=0.06u
MI48_1 ZN A4 VSS VSS nch w=0.39u l=0.06u
MI48_2 ZN A4 VSS VSS nch w=0.39u l=0.06u
MI47_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI47_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI47_2 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI46_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI46_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI46_2 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI42_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI42_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI42_2 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI52 net042 A3 net039 VDD pch w=3.12u l=0.06u
MI53 net036 A2 net042 VDD pch w=3.13u l=0.06u
MI54 ZN A1 net036 VDD pch w=3.17u l=0.06u
MI7 net039 A4 VDD VDD pch w=3.13u l=0.06u
.ends
.subckt NR4D4 A1 A2 A3 A4 ZN VDD VSS
MI46-M_u4 ZN A4 VSS VSS nch w=1.56u l=0.06u
MI46-M_u3 ZN A3 VSS VSS nch w=1.56u l=0.06u
MI46-M_u5 ZN A2 VSS VSS nch w=1.56u l=0.06u
MI46-M_u8 ZN A1 VSS VSS nch w=1.56u l=0.06u
MI46-M_u7 ZN A1 XI46-net7 VDD pch w=4.02u l=0.06u
MI46-M_u6 XI46-net7 A2 XI46-net10 VDD pch w=4.02u l=0.06u
MI46-M_u2 XI46-net10 A3 XI46-net13 VDD pch w=4.02u l=0.06u
MI46-M_u1 XI46-net13 A4 VDD VDD pch w=4.02u l=0.06u
.ends
.subckt NR4D8 A1 A2 A3 A4 ZN VDD VSS
MI42-M_u4 net21 A4 VSS VSS nch w=0.39u l=0.06u
MI42-M_u3 net21 A3 VSS VSS nch w=0.39u l=0.06u
MI42-M_u5 net21 A2 VSS VSS nch w=0.39u l=0.06u
MI42-M_u8 net21 A1 VSS VSS nch w=0.39u l=0.06u
MI41_0-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_1-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_2-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_3-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_4-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_5-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_6-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI41_7-M_u2 ZN n0 VSS VSS nch w=0.39u l=0.06u
MI43_0-M_u2 n0 net21 VSS VSS nch w=0.39u l=0.06u
MI43_1-M_u2 n0 net21 VSS VSS nch w=0.39u l=0.06u
MI43_2-M_u2 n0 net21 VSS VSS nch w=0.39u l=0.06u
MI42-M_u7 net21 A1 XI42-net7 VDD pch w=0.52u l=0.06u
MI42-M_u6 XI42-net7 A2 XI42-net10 VDD pch w=0.52u l=0.06u
MI42-M_u2 XI42-net10 A3 XI42-net13 VDD pch w=0.52u l=0.06u
MI42-M_u1 XI42-net13 A4 VDD VDD pch w=0.52u l=0.06u
MI41_0-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_1-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_2-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_3-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_4-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_5-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_6-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI41_7-M_u3 ZN n0 VDD VDD pch w=0.52u l=0.06u
MI43_0-M_u3 n0 net21 VDD VDD pch w=0.52u l=0.06u
MI43_1-M_u3 n0 net21 VDD VDD pch w=0.52u l=0.06u
MI43_2-M_u3 n0 net21 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA211D0 A1 A2 B C Z VDD VSS
MI8 net36 B net24 VSS nch w=0.195u l=0.06u
MI9 net24 C VSS VSS nch w=0.195u l=0.06u
M_u2 net33 A1 net36 VSS nch w=0.195u l=0.06u
MI7 net33 A2 net36 VSS nch w=0.195u l=0.06u
MI11-M_u2 Z net33 VSS VSS nch w=0.195u l=0.06u
MI11-M_u3 Z net33 VDD VDD pch w=0.26u l=0.06u
MI6 net33 A2 net35 VDD pch w=0.26u l=0.06u
MI5 net35 A1 VDD VDD pch w=0.26u l=0.06u
MI4 net33 C VDD VDD pch w=0.26u l=0.06u
M_u12 net33 B VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA211D1 A1 A2 B C Z VDD VSS
MI16 net36 B net24 VSS nch w=0.39u l=0.06u
MI17 net24 C VSS VSS nch w=0.39u l=0.06u
MI15 net33 A1 net36 VSS nch w=0.39u l=0.06u
MI7 net33 A2 net36 VSS nch w=0.39u l=0.06u
MI11-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI11-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI14 net33 A2 net35 VDD pch w=0.52u l=0.06u
MI13 net35 A1 VDD VDD pch w=0.52u l=0.06u
MI12 net33 C VDD VDD pch w=0.52u l=0.06u
M_u12 net33 B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA211D2 A1 A2 B C Z VDD VSS
MI16 net36 B net24 VSS nch w=0.39u l=0.06u
MI17 net24 C VSS VSS nch w=0.39u l=0.06u
MI15 net33 A1 net36 VSS nch w=0.39u l=0.06u
MI7 net33 A2 net36 VSS nch w=0.39u l=0.06u
MI11_0-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI14 net33 A2 net35 VDD pch w=0.52u l=0.06u
MI13 net35 A1 VDD VDD pch w=0.52u l=0.06u
MI12 net33 C VDD VDD pch w=0.52u l=0.06u
M_u12 net33 B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA211D4 A1 A2 B C Z VDD VSS
MI16_0 net029 B net020<0> VSS nch w=0.39u l=0.06u
MI16_1 net029 B net020<1> VSS nch w=0.39u l=0.06u
MI24_0 net020<0> C VSS VSS nch w=0.39u l=0.06u
MI24_1 net020<1> C VSS VSS nch w=0.39u l=0.06u
MI23 p0 A1 net029 VSS nch w=0.78u l=0.06u
MI25 p0 A2 net029 VSS nch w=0.78u l=0.06u
MI11_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI11_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI11_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI11_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI11_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI28_0 p0 A2 net041<0> VDD pch w=0.52u l=0.06u
MI28_1 p0 A2 net041<1> VDD pch w=0.52u l=0.06u
MI27_0 net041<0> A1 VDD VDD pch w=0.52u l=0.06u
MI27_1 net041<1> A1 VDD VDD pch w=0.52u l=0.06u
MI19_0 p0 C VDD VDD pch w=0.52u l=0.06u
MI19_1 p0 C VDD VDD pch w=0.52u l=0.06u
MI20_0 p0 B VDD VDD pch w=0.52u l=0.06u
MI20_1 p0 B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA21D0 A1 A2 B Z VDD VSS
MI19 net14 A2 net20 VSS nch w=0.195u l=0.06u
MI11 net14 A1 net20 VSS nch w=0.195u l=0.06u
MI20 net20 B VSS VSS nch w=0.195u l=0.06u
MI8-M_u2 Z net14 VSS VSS nch w=0.195u l=0.06u
MI8-M_u3 Z net14 VDD VDD pch w=0.26u l=0.06u
M_u2 net14 B VDD VDD pch w=0.26u l=0.06u
MI17 net24 A2 VDD VDD pch w=0.26u l=0.06u
MI18 net14 A1 net24 VDD pch w=0.26u l=0.06u
.ends
.subckt OA21D1 A1 A2 B Z VDD VSS
MI12 net14 A2 net20 VSS nch w=0.39u l=0.06u
MI11 net14 A1 net20 VSS nch w=0.39u l=0.06u
MI6 net20 B VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MI8-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u2 net14 B VDD VDD pch w=0.52u l=0.06u
MI7 net24 A2 VDD VDD pch w=0.52u l=0.06u
MI9 net14 A1 net24 VDD pch w=0.52u l=0.06u
.ends
.subckt OA21D2 A1 A2 B Z VDD VSS
MI12 net14 A2 net20 VSS nch w=0.39u l=0.06u
MI11 net14 A1 net20 VSS nch w=0.39u l=0.06u
MI6 net20 B VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u2 net14 B VDD VDD pch w=0.52u l=0.06u
MI7 net24 A2 VDD VDD pch w=0.52u l=0.06u
MI9 net14 A1 net24 VDD pch w=0.52u l=0.06u
.ends
.subckt OA21D4 A1 A2 B Z VDD VSS
MI23 net021 B VSS VSS nch w=0.78u l=0.06u
MI11 p0 A1 net021 VSS nch w=0.78u l=0.06u
MI21 p0 A2 net021 VSS nch w=0.78u l=0.06u
MI8_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0 p0 B VDD VDD pch w=0.52u l=0.06u
M_u2_1 p0 B VDD VDD pch w=0.52u l=0.06u
MI13_0 net40<0> A2 VDD VDD pch w=0.52u l=0.06u
MI13_1 net40<1> A2 VDD VDD pch w=0.52u l=0.06u
MI14_0 p0 A1 net40<0> VDD pch w=0.52u l=0.06u
MI14_1 p0 A1 net40<1> VDD pch w=0.52u l=0.06u
.ends
.subckt OA221D0 A1 A2 B1 B2 C Z VDD VSS
MI14 net32 A2 net26 VSS nch w=0.195u l=0.06u
MI7 net32 A1 net26 VSS nch w=0.195u l=0.06u
MI6 net29 C VSS VSS nch w=0.195u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.195u l=0.06u
MI5 net26 B2 net29 VSS nch w=0.195u l=0.06u
MI15-M_u2 Z net32 VSS VSS nch w=0.195u l=0.06u
MI13 net32 A1 net43 VDD pch w=0.26u l=0.06u
MI11 net32 B2 net49 VDD pch w=0.26u l=0.06u
MI9 net49 B1 VDD VDD pch w=0.26u l=0.06u
MI12 net43 A2 VDD VDD pch w=0.26u l=0.06u
MU24 net32 C VDD VDD pch w=0.26u l=0.06u
MI15-M_u3 Z net32 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA221D1 A1 A2 B1 B2 C Z VDD VSS
MI14 net32 A2 net26 VSS nch w=0.39u l=0.06u
MI7 net32 A1 net26 VSS nch w=0.39u l=0.06u
MI6 net29 C VSS VSS nch w=0.39u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.39u l=0.06u
MI5 net26 B2 net29 VSS nch w=0.39u l=0.06u
MI15-M_u2 Z net32 VSS VSS nch w=0.39u l=0.06u
MI13 net32 A1 net43 VDD pch w=0.52u l=0.06u
MI11 net32 B2 net49 VDD pch w=0.52u l=0.06u
MI9 net49 B1 VDD VDD pch w=0.52u l=0.06u
MI12 net43 A2 VDD VDD pch w=0.52u l=0.06u
MU24 net32 C VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 Z net32 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA221D2 A1 A2 B1 B2 C Z VDD VSS
MI14 net32 A2 net26 VSS nch w=0.39u l=0.06u
MI7 net32 A1 net26 VSS nch w=0.39u l=0.06u
MI6 net29 C VSS VSS nch w=0.39u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.39u l=0.06u
MI5 net26 B2 net29 VSS nch w=0.39u l=0.06u
MI15_0-M_u2 Z net32 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u2 Z net32 VSS VSS nch w=0.39u l=0.06u
MI13 net32 A1 net43 VDD pch w=0.52u l=0.06u
MI11 net32 B2 net49 VDD pch w=0.52u l=0.06u
MI9 net49 B1 VDD VDD pch w=0.52u l=0.06u
MI12 net43 A2 VDD VDD pch w=0.52u l=0.06u
MU24 net32 C VDD VDD pch w=0.52u l=0.06u
MI15_0-M_u3 Z net32 VDD VDD pch w=0.52u l=0.06u
MI15_1-M_u3 Z net32 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA221D4 A1 A2 B1 B2 C Z VDD VSS
MI28 net030 B1 net036 VSS nch w=0.78u l=0.06u
MI30 p0 A1 net030 VSS nch w=0.78u l=0.06u
MI29 net030 B2 net036 VSS nch w=0.78u l=0.06u
MI27 net036 C VSS VSS nch w=0.78u l=0.06u
MI31 p0 A2 net030 VSS nch w=0.78u l=0.06u
MI15_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI15_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI15_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI19_0 p0 C VDD VDD pch w=0.52u l=0.06u
MI19_1 p0 C VDD VDD pch w=0.52u l=0.06u
MI16_0 p0 A1 net58<0> VDD pch w=0.52u l=0.06u
MI16_1 p0 A1 net58<1> VDD pch w=0.52u l=0.06u
MI18_0 net55<0> B1 VDD VDD pch w=0.52u l=0.06u
MI18_1 net55<1> B1 VDD VDD pch w=0.52u l=0.06u
MI17_0 p0 B2 net55<0> VDD pch w=0.52u l=0.06u
MI17_1 p0 B2 net55<1> VDD pch w=0.52u l=0.06u
MI12_0 net58<0> A2 VDD VDD pch w=0.52u l=0.06u
MI12_1 net58<1> A2 VDD VDD pch w=0.52u l=0.06u
MI15_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI15_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI15_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI15_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA222D0 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI18 net36 A2 net27 VSS nch w=0.195u l=0.06u
MI14 net39 C2 VSS VSS nch w=0.195u l=0.06u
MI15 net27 B1 net39 VSS nch w=0.195u l=0.06u
MI16 net27 B2 net39 VSS nch w=0.195u l=0.06u
MI17 net36 A1 net27 VSS nch w=0.195u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.195u l=0.06u
MI19-M_u2 Z net36 VSS VSS nch w=0.195u l=0.06u
MI8 net36 C2 net46 VDD pch w=0.26u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.26u l=0.06u
MI13 net36 A1 net34 VDD pch w=0.26u l=0.06u
MI12 net34 A2 VDD VDD pch w=0.26u l=0.06u
MI9 net36 B2 net37 VDD pch w=0.26u l=0.06u
MI11 net37 B1 VDD VDD pch w=0.26u l=0.06u
MI19-M_u3 Z net36 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA222D1 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI18 net36 A2 net27 VSS nch w=0.39u l=0.06u
MI14 net39 C2 VSS VSS nch w=0.39u l=0.06u
MI15 net27 B1 net39 VSS nch w=0.39u l=0.06u
MI16 net27 B2 net39 VSS nch w=0.39u l=0.06u
MI17 net36 A1 net27 VSS nch w=0.39u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.39u l=0.06u
MI19-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI8 net36 C2 net46 VDD pch w=0.52u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.52u l=0.06u
MI13 net36 A1 net34 VDD pch w=0.52u l=0.06u
MI12 net34 A2 VDD VDD pch w=0.52u l=0.06u
MI9 net36 B2 net37 VDD pch w=0.52u l=0.06u
MI11 net37 B1 VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA222D2 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI18 net36 A2 net27 VSS nch w=0.39u l=0.06u
MI14 net39 C2 VSS VSS nch w=0.39u l=0.06u
MI15 net27 B1 net39 VSS nch w=0.39u l=0.06u
MI16 net27 B2 net39 VSS nch w=0.39u l=0.06u
MI17 net36 A1 net27 VSS nch w=0.39u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.39u l=0.06u
MI19_0-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI19_1-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI8 net36 C2 net46 VDD pch w=0.52u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.52u l=0.06u
MI13 net36 A1 net34 VDD pch w=0.52u l=0.06u
MI12 net34 A2 VDD VDD pch w=0.52u l=0.06u
MI9 net36 B2 net37 VDD pch w=0.52u l=0.06u
MI11 net37 B1 VDD VDD pch w=0.52u l=0.06u
MI19_0-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
MI19_1-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA222D4 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI34 net36 A2 net27 VSS nch w=0.78u l=0.06u
MI30 net39 C2 VSS VSS nch w=0.78u l=0.06u
MI31 net27 B1 net39 VSS nch w=0.78u l=0.06u
MI32 net27 B2 net39 VSS nch w=0.78u l=0.06u
MI33 net36 A1 net27 VSS nch w=0.78u l=0.06u
MI29 net39 C1 VSS VSS nch w=0.78u l=0.06u
MI19_0-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI19_1-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI19_2-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI19_3-M_u2 Z net36 VSS VSS nch w=0.39u l=0.06u
MI23_0 net57<0> C1 VDD VDD pch w=0.52u l=0.06u
MI23_1 net57<1> C1 VDD VDD pch w=0.52u l=0.06u
MI24_0 net36 C2 net57<0> VDD pch w=0.52u l=0.06u
MI24_1 net36 C2 net57<1> VDD pch w=0.52u l=0.06u
MI20_0 net36 A1 net69<0> VDD pch w=0.52u l=0.06u
MI20_1 net36 A1 net69<1> VDD pch w=0.52u l=0.06u
MI12_0 net69<0> A2 VDD VDD pch w=0.52u l=0.06u
MI12_1 net69<1> A2 VDD VDD pch w=0.52u l=0.06u
MI21_0 net36 B2 net66<0> VDD pch w=0.52u l=0.06u
MI21_1 net36 B2 net66<1> VDD pch w=0.52u l=0.06u
MI22_0 net66<0> B1 VDD VDD pch w=0.52u l=0.06u
MI22_1 net66<1> B1 VDD VDD pch w=0.52u l=0.06u
MI19_0-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
MI19_1-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
MI19_2-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
MI19_3-M_u3 Z net36 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA22D0 A1 A2 B1 B2 Z VDD VSS
M_u4 net29 B2 VSS VSS nch w=0.195u l=0.06u
MI19 net30 A2 net29 VSS nch w=0.195u l=0.06u
MI20 net30 A1 net29 VSS nch w=0.195u l=0.06u
MI18 net29 B1 VSS VSS nch w=0.195u l=0.06u
MU1-M_u2 Z net30 VSS VSS nch w=0.195u l=0.06u
MU24 net25 B2 VDD VDD pch w=0.26u l=0.06u
MI16 net22 A2 VDD VDD pch w=0.26u l=0.06u
MI15 net30 B1 net25 VDD pch w=0.26u l=0.06u
MI17 net30 A1 net22 VDD pch w=0.26u l=0.06u
MU1-M_u3 Z net30 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA22D1 A1 A2 B1 B2 Z VDD VSS
M_u4 net29 B2 VSS VSS nch w=0.39u l=0.06u
MI13 net30 A2 net29 VSS nch w=0.39u l=0.06u
MI14 net30 A1 net29 VSS nch w=0.39u l=0.06u
MI12 net29 B1 VSS VSS nch w=0.39u l=0.06u
MU1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU24 net25 B2 VDD VDD pch w=0.52u l=0.06u
MI11 net22 A2 VDD VDD pch w=0.52u l=0.06u
MI8 net30 B1 net25 VDD pch w=0.52u l=0.06u
MI9 net30 A1 net22 VDD pch w=0.52u l=0.06u
MU1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA22D2 A1 A2 B1 B2 Z VDD VSS
M_u4 net29 B2 VSS VSS nch w=0.39u l=0.06u
MI13 net30 A2 net29 VSS nch w=0.39u l=0.06u
MI14 net30 A1 net29 VSS nch w=0.39u l=0.06u
MI12 net29 B1 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU24 net25 B2 VDD VDD pch w=0.52u l=0.06u
MI11 net22 A2 VDD VDD pch w=0.52u l=0.06u
MI8 net30 B1 net25 VDD pch w=0.52u l=0.06u
MI9 net30 A1 net22 VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA22D4 A1 A2 B1 B2 Z VDD VSS
MI27 net035 B2 VSS VSS nch w=0.78u l=0.06u
MI25 p0 A2 net035 VSS nch w=0.78u l=0.06u
MI22 p0 A1 net035 VSS nch w=0.78u l=0.06u
MI26 net035 B1 VSS VSS nch w=0.78u l=0.06u
MU1_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI18_0 p0 B1 net39<0> VDD pch w=0.52u l=0.06u
MI18_1 p0 B1 net39<1> VDD pch w=0.52u l=0.06u
MI11_0 net48<0> A2 VDD VDD pch w=0.52u l=0.06u
MI11_1 net48<1> A2 VDD VDD pch w=0.52u l=0.06u
MI17_0 net39<0> B2 VDD VDD pch w=0.52u l=0.06u
MI17_1 net39<1> B2 VDD VDD pch w=0.52u l=0.06u
MI15_0 p0 A1 net48<0> VDD pch w=0.52u l=0.06u
MI15_1 p0 A1 net48<1> VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA31D0 A1 A2 A3 B Z VDD VSS
M_u5 VSS B net22 VSS nch w=0.195u l=0.06u
MI15 net22 A3 net30 VSS nch w=0.195u l=0.06u
MI14 net22 A2 net30 VSS nch w=0.195u l=0.06u
MI13 net22 A1 net30 VSS nch w=0.195u l=0.06u
MU1-M_u2 Z net30 VSS VSS nch w=0.195u l=0.06u
MI3 net38 A1 VDD VDD pch w=0.26u l=0.06u
MI9 net35 A2 net38 VDD pch w=0.26u l=0.06u
MI11 net30 A3 net35 VDD pch w=0.26u l=0.06u
MI12 net30 B VDD VDD pch w=0.26u l=0.06u
MU1-M_u3 Z net30 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA31D1 A1 A2 A3 B Z VDD VSS
M_u5 VSS B net22 VSS nch w=0.39u l=0.06u
MI8 net22 A3 net30 VSS nch w=0.39u l=0.06u
MI7 net22 A2 net30 VSS nch w=0.39u l=0.06u
MI6 net22 A1 net30 VSS nch w=0.39u l=0.06u
MU1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI3 net38 A1 VDD VDD pch w=0.52u l=0.06u
MI4 net35 A2 net38 VDD pch w=0.52u l=0.06u
MI5 net30 A3 net35 VDD pch w=0.52u l=0.06u
M_u11 net30 B VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA31D2 A1 A2 A3 B Z VDD VSS
M_u5 VSS B net22 VSS nch w=0.39u l=0.06u
MI8 net22 A3 net30 VSS nch w=0.39u l=0.06u
MI7 net22 A2 net30 VSS nch w=0.39u l=0.06u
MI6 net22 A1 net30 VSS nch w=0.39u l=0.06u
MU1_0-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI3 net38 A1 VDD VDD pch w=0.52u l=0.06u
MI4 net35 A2 net38 VDD pch w=0.52u l=0.06u
MI5 net30 A3 net35 VDD pch w=0.52u l=0.06u
M_u11 net30 B VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA31D4 A1 A2 A3 B Z VDD VSS
MI17 VSS B net025 VSS nch w=0.78u l=0.06u
MI25 net025 A3 net30 VSS nch w=0.78u l=0.06u
MI24 net025 A2 net30 VSS nch w=0.78u l=0.06u
MI23 net025 A1 net30 VSS nch w=0.78u l=0.06u
MU1_0-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI3_0 net44<0> A1 VDD VDD pch w=0.52u l=0.06u
MI3_1 net44<1> A1 VDD VDD pch w=0.52u l=0.06u
MI18_0 net41<0> A2 net44<0> VDD pch w=0.52u l=0.06u
MI18_1 net41<1> A2 net44<1> VDD pch w=0.52u l=0.06u
MI19_0 net30 A3 net41<0> VDD pch w=0.52u l=0.06u
MI19_1 net30 A3 net41<1> VDD pch w=0.52u l=0.06u
M_u11 net30 B VDD VDD pch w=1.04u l=0.06u
MU1_0-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA32D0 A1 A2 A3 B1 B2 Z VDD VSS
MI12 net14 B1 VSS VSS nch w=0.195u l=0.06u
MI11 net14 B2 VSS VSS nch w=0.195u l=0.06u
MI3 net35 A3 net14 VSS nch w=0.195u l=0.06u
MI8 net35 A2 net14 VSS nch w=0.195u l=0.06u
MI9 net35 A1 net14 VSS nch w=0.195u l=0.06u
MU1-M_u2 Z net35 VSS VSS nch w=0.195u l=0.06u
MI16-MI12 net35 B2 XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.26u l=0.06u
MI15-MI12 net35 A3 XI15-net11 VDD pch w=0.26u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.26u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.26u l=0.06u
MU1-M_u3 Z net35 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA32D1 A1 A2 A3 B1 B2 Z VDD VSS
MI7 net14 B1 VSS VSS nch w=0.39u l=0.06u
MI6 net14 B2 VSS VSS nch w=0.39u l=0.06u
MI3 net35 A3 net14 VSS nch w=0.39u l=0.06u
MI4 net35 A2 net14 VSS nch w=0.39u l=0.06u
MI5 net35 A1 net14 VSS nch w=0.39u l=0.06u
MU1-M_u2 Z net35 VSS VSS nch w=0.39u l=0.06u
MI16-MI12 net35 B2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15-MI12 net35 A3 XI15-net11 VDD pch w=0.52u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.52u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 Z net35 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA32D2 A1 A2 A3 B1 B2 Z VDD VSS
MI7 net14 B1 VSS VSS nch w=0.39u l=0.06u
MI6 net14 B2 VSS VSS nch w=0.39u l=0.06u
MI3 net35 A3 net14 VSS nch w=0.39u l=0.06u
MI4 net35 A2 net14 VSS nch w=0.39u l=0.06u
MI5 net35 A1 net14 VSS nch w=0.39u l=0.06u
MU1_0-M_u2 Z net35 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net35 VSS VSS nch w=0.39u l=0.06u
MI16-MI12 net35 B2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15-MI12 net35 A3 XI15-net11 VDD pch w=0.52u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.52u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z net35 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net35 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA32D4 A1 A2 A3 B1 B2 Z VDD VSS
MI22 net028 B1 VSS VSS nch w=0.78u l=0.06u
MI23 net028 B2 VSS VSS nch w=0.78u l=0.06u
MI26 p0 A3 net028 VSS nch w=0.78u l=0.06u
MI25 p0 A2 net028 VSS nch w=0.78u l=0.06u
MI24 p0 A1 net028 VSS nch w=0.78u l=0.06u
MU1_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_0-MI12 p0 B2 XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 p0 B2 XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15_0-MI12 p0 A3 XI15_0-net11 VDD pch w=0.52u l=0.06u
MI15_0-MI13 XI15_0-net11 A2 XI15_0-net18 VDD pch w=0.52u l=0.06u
MI15_0-MI15 XI15_0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MI15_1-MI12 p0 A3 XI15_1-net11 VDD pch w=0.52u l=0.06u
MI15_1-MI13 XI15_1-net11 A2 XI15_1-net18 VDD pch w=0.52u l=0.06u
MI15_1-MI15 XI15_1-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA33D0 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI12 net15 B2 VSS VSS nch w=0.195u l=0.06u
MI13 net15 B1 VSS VSS nch w=0.195u l=0.06u
M_u3 net37 A3 net15 VSS nch w=0.195u l=0.06u
MI8 net37 A2 net15 VSS nch w=0.195u l=0.06u
MI11 net15 B3 VSS VSS nch w=0.195u l=0.06u
MI9 net37 A1 net15 VSS nch w=0.195u l=0.06u
MU1-M_u2 Z net37 VSS VSS nch w=0.195u l=0.06u
MI1-MI12 net37 B3 XI1-net11 VDD pch w=0.26u l=0.06u
MI1-MI13 XI1-net11 B2 XI1-net18 VDD pch w=0.26u l=0.06u
MI1-MI15 XI1-net18 B1 VDD VDD pch w=0.26u l=0.06u
MI7-MI12 net37 A3 XI7-net11 VDD pch w=0.26u l=0.06u
MI7-MI13 XI7-net11 A2 XI7-net18 VDD pch w=0.26u l=0.06u
MI7-MI15 XI7-net18 A1 VDD VDD pch w=0.26u l=0.06u
MU1-M_u3 Z net37 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OA33D1 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI5 net15 B2 VSS VSS nch w=0.39u l=0.06u
MI6 net15 B1 VSS VSS nch w=0.39u l=0.06u
M_u3 net37 A3 net15 VSS nch w=0.39u l=0.06u
MI2 net37 A2 net15 VSS nch w=0.39u l=0.06u
MI4 net15 B3 VSS VSS nch w=0.39u l=0.06u
MI3 net37 A1 net15 VSS nch w=0.39u l=0.06u
MU1-M_u2 Z net37 VSS VSS nch w=0.39u l=0.06u
MI1-MI12 net37 B3 XI1-net11 VDD pch w=0.52u l=0.06u
MI1-MI13 XI1-net11 B2 XI1-net18 VDD pch w=0.52u l=0.06u
MI1-MI15 XI1-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI0-MI12 net37 A3 XI0-net11 VDD pch w=0.52u l=0.06u
MI0-MI13 XI0-net11 A2 XI0-net18 VDD pch w=0.52u l=0.06u
MI0-MI15 XI0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 Z net37 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA33D2 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI5 net15 B2 VSS VSS nch w=0.39u l=0.06u
MI6 net15 B1 VSS VSS nch w=0.39u l=0.06u
M_u3 net37 A3 net15 VSS nch w=0.39u l=0.06u
MI2 net37 A2 net15 VSS nch w=0.39u l=0.06u
MI4 net15 B3 VSS VSS nch w=0.39u l=0.06u
MI3 net37 A1 net15 VSS nch w=0.39u l=0.06u
MU1_0-M_u2 Z net37 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net37 VSS VSS nch w=0.39u l=0.06u
MI1-MI12 net37 B3 XI1-net11 VDD pch w=0.52u l=0.06u
MI1-MI13 XI1-net11 B2 XI1-net18 VDD pch w=0.52u l=0.06u
MI1-MI15 XI1-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI0-MI12 net37 A3 XI0-net11 VDD pch w=0.52u l=0.06u
MI0-MI13 XI0-net11 A2 XI0-net18 VDD pch w=0.52u l=0.06u
MI0-MI15 XI0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z net37 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net37 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OA33D4 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI23 net15 B2 VSS VSS nch w=0.78u l=0.06u
MI24 net15 B1 VSS VSS nch w=0.78u l=0.06u
MI12 net31 A3 net15 VSS nch w=0.78u l=0.06u
MI20 net31 A2 net15 VSS nch w=0.78u l=0.06u
MI22 net15 B3 VSS VSS nch w=0.78u l=0.06u
MI21 net31 A1 net15 VSS nch w=0.78u l=0.06u
MU1_0-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MI13_0-MI12 net31 B3 XI13_0-net11 VDD pch w=0.52u l=0.06u
MI13_0-MI13 XI13_0-net11 B2 XI13_0-net18 VDD pch w=0.52u l=0.06u
MI13_0-MI15 XI13_0-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI13_1-MI12 net31 B3 XI13_1-net11 VDD pch w=0.52u l=0.06u
MI13_1-MI13 XI13_1-net11 B2 XI13_1-net18 VDD pch w=0.52u l=0.06u
MI13_1-MI15 XI13_1-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI19_0-MI12 net31 A3 XI19_0-net11 VDD pch w=0.52u l=0.06u
MI19_0-MI13 XI19_0-net11 A2 XI19_0-net18 VDD pch w=0.52u l=0.06u
MI19_0-MI15 XI19_0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MI19_1-MI12 net31 A3 XI19_1-net11 VDD pch w=0.52u l=0.06u
MI19_1-MI13 XI19_1-net11 A2 XI19_1-net18 VDD pch w=0.52u l=0.06u
MI19_1-MI15 XI19_1-net18 A1 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI211D0 A1 A2 B C ZN VDD VSS
MI8 net36 B net24 VSS nch w=0.195u l=0.06u
MI9 net24 C VSS VSS nch w=0.195u l=0.06u
M_u2 ZN A1 net36 VSS nch w=0.195u l=0.06u
MI7 ZN A2 net36 VSS nch w=0.195u l=0.06u
MI6 ZN A2 net35 VDD pch w=0.26u l=0.06u
MI5 net35 A1 VDD VDD pch w=0.26u l=0.06u
MI4 ZN C VDD VDD pch w=0.26u l=0.06u
M_u12 ZN B VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI211D1 A1 A2 B C ZN VDD VSS
MI2 net36 B net24 VSS nch w=0.39u l=0.06u
MI3 net24 C VSS VSS nch w=0.39u l=0.06u
M_u2 ZN A1 net36 VSS nch w=0.39u l=0.06u
M_u3 ZN A2 net36 VSS nch w=0.39u l=0.06u
MI1 ZN A2 net35 VDD pch w=0.52u l=0.06u
MI0 net35 A1 VDD VDD pch w=0.52u l=0.06u
M_u11 ZN C VDD VDD pch w=0.52u l=0.06u
M_u12 ZN B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI211D2 A1 A2 B C ZN VDD VSS
MI8_0 net36 B net25<0> VSS nch w=0.39u l=0.06u
MI8_1 net36 B net25<1> VSS nch w=0.39u l=0.06u
MI11_0 net25<0> C VSS VSS nch w=0.39u l=0.06u
MI11_1 net25<1> C VSS VSS nch w=0.39u l=0.06u
M_u2 ZN A1 net36 VSS nch w=0.78u l=0.06u
MI13 ZN A2 net36 VSS nch w=0.78u l=0.06u
MI12_0 ZN A2 net38<0> VDD pch w=0.52u l=0.06u
MI12_1 ZN A2 net38<1> VDD pch w=0.52u l=0.06u
MI5_0 net38<0> A1 VDD VDD pch w=0.52u l=0.06u
MI5_1 net38<1> A1 VDD VDD pch w=0.52u l=0.06u
MI4 ZN C VDD VDD pch w=1.04u l=0.06u
M_u12 ZN B VDD VDD pch w=1.04u l=0.06u
.ends
.subckt OAI211D4 A1 A2 B C ZN VDD VSS
MI21 net33 B net25 VSS nch w=1.56u l=0.06u
MI22 net25 C VSS VSS nch w=1.56u l=0.06u
M_u2 ZN A1 net33 VSS nch w=1.56u l=0.06u
MI20 ZN A2 net33 VSS nch w=1.56u l=0.06u
MI19 ZN A2 net44 VDD pch w=2.08u l=0.06u
MI18 net44 A1 VDD VDD pch w=2.08u l=0.06u
MI17 ZN C VDD VDD pch w=2.08u l=0.06u
MI16 ZN B VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI21D0 A1 A2 B ZN VDD VSS
M_u2 ZN A1 net15 VSS nch w=0.195u l=0.06u
M_u3 ZN A2 net15 VSS nch w=0.195u l=0.06u
M_u4 net15 B VSS VSS nch w=0.195u l=0.06u
M_u9 ZN B VDD VDD pch w=0.26u l=0.06u
MI16-MI12 ZN A1 XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 A2 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI21D1 A1 A2 B ZN VDD VSS
M_u2 ZN A1 net15 VSS nch w=0.39u l=0.06u
M_u3 ZN A2 net15 VSS nch w=0.39u l=0.06u
M_u4 net15 B VSS VSS nch w=0.39u l=0.06u
M_u9 ZN B VDD VDD pch w=0.52u l=0.06u
MI16-MI12 ZN A1 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI21D2 A1 A2 B ZN VDD VSS
MI0 ZN A1 net15 VSS nch w=0.78u l=0.06u
M_u3 ZN A2 net15 VSS nch w=0.78u l=0.06u
MI1 net15 B VSS VSS nch w=0.78u l=0.06u
M_u9_0 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_1 ZN B VDD VDD pch w=0.52u l=0.06u
MI16_0-MI12 ZN A1 XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 A2 VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 ZN A1 XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI21D4 A1 A2 B ZN VDD VSS
MI3 ZN A1 net023 VSS nch w=1.56u l=0.06u
MI4 net023 B VSS VSS nch w=1.56u l=0.06u
M_u3 ZN A2 net023 VSS nch w=1.56u l=0.06u
M_u9_0 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_1 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_2 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_3 ZN B VDD VDD pch w=0.52u l=0.06u
MI16-MI12 ZN A1 XI16-net11 VDD pch w=2.08u l=0.06u
MI16-MI13 XI16-net11 A2 VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI221D0 A1 A2 B1 B2 C ZN VDD VSS
MI14 ZN A2 net26 VSS nch w=0.195u l=0.06u
MI7 ZN A1 net26 VSS nch w=0.195u l=0.06u
MI6 net29 C VSS VSS nch w=0.195u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.195u l=0.06u
MI5 net26 B2 net29 VSS nch w=0.195u l=0.06u
MI13 ZN A1 net43 VDD pch w=0.26u l=0.06u
MI11 ZN B2 net49 VDD pch w=0.26u l=0.06u
MI9 net49 B1 VDD VDD pch w=0.26u l=0.06u
MI12 net43 A2 VDD VDD pch w=0.26u l=0.06u
MU24 ZN C VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI221D1 A1 A2 B1 B2 C ZN VDD VSS
M_u2 ZN A1 net26 VSS nch w=0.39u l=0.06u
M_u3 ZN A2 net26 VSS nch w=0.39u l=0.06u
M_u5 net26 B2 net29 VSS nch w=0.39u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.39u l=0.06u
MU23 net29 C VSS VSS nch w=0.39u l=0.06u
MI2 ZN B2 net49 VDD pch w=0.52u l=0.06u
MI3 net43 A2 VDD VDD pch w=0.52u l=0.06u
MI4 ZN A1 net43 VDD pch w=0.52u l=0.06u
MI1 net49 B1 VDD VDD pch w=0.52u l=0.06u
MU24 ZN C VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI221D2 A1 A2 B1 B2 C ZN VDD VSS
MI18 ZN A1 net26 VSS nch w=0.78u l=0.06u
MI14 ZN A2 net26 VSS nch w=0.78u l=0.06u
MI19 net26 B2 net29 VSS nch w=0.78u l=0.06u
MI21 net29 C VSS VSS nch w=0.78u l=0.06u
MI20 net26 B1 net29 VSS nch w=0.78u l=0.06u
MI17_0 net49<0> A2 VDD VDD pch w=0.52u l=0.06u
MI17_1 net49<1> A2 VDD VDD pch w=0.52u l=0.06u
MI15_0 ZN B2 net52<0> VDD pch w=0.52u l=0.06u
MI15_1 ZN B2 net52<1> VDD pch w=0.52u l=0.06u
MI9_0 net52<0> B1 VDD VDD pch w=0.52u l=0.06u
MI9_1 net52<1> B1 VDD VDD pch w=0.52u l=0.06u
MI16_0 ZN A1 net49<0> VDD pch w=0.52u l=0.06u
MI16_1 ZN A1 net49<1> VDD pch w=0.52u l=0.06u
MU24 ZN C VDD VDD pch w=1.04u l=0.06u
.ends
.subckt OAI221D4 A1 A2 B1 B2 C ZN VDD VSS
M_u2 net79 A1 net26 VSS nch w=0.39u l=0.06u
M_u3 net79 A2 net26 VSS nch w=0.39u l=0.06u
M_u5 net26 B2 net29 VSS nch w=0.39u l=0.06u
M_u4 net26 B1 net29 VSS nch w=0.39u l=0.06u
MU23 net29 C VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net80 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 ZN net80 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net80 net79 VSS VSS nch w=0.39u l=0.06u
MI6-M_u2 ZN net80 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net80 VSS VSS nch w=0.39u l=0.06u
MI2 net79 B2 net49 VDD pch w=0.52u l=0.06u
MI3 net43 A2 VDD VDD pch w=0.52u l=0.06u
MI4 net79 A1 net43 VDD pch w=0.52u l=0.06u
MI1 net49 B1 VDD VDD pch w=0.52u l=0.06u
MU24 net79 C VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net80 VDD VDD pch w=0.52u l=0.06u
MI8-M_u3 ZN net80 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net80 net79 VDD VDD pch w=0.52u l=0.06u
MI6-M_u3 ZN net80 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net80 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI221XD4 A1 A2 B1 B2 C ZN VDD VSS
MI14 ZN A2 net26 VSS nch w=1.56u l=0.06u
M_u2 ZN A1 net26 VSS nch w=1.56u l=0.06u
MI15 net26 B2 net29 VSS nch w=1.56u l=0.06u
MI16 net26 B1 net29 VSS nch w=1.56u l=0.06u
MI17 net29 C VSS VSS nch w=1.56u l=0.06u
MI11 ZN B2 net49 VDD pch w=2.08u l=0.06u
MI13 ZN A1 net43 VDD pch w=2.08u l=0.06u
MI12 net43 A2 VDD VDD pch w=2.08u l=0.06u
MI9 net49 B1 VDD VDD pch w=2.08u l=0.06u
MU24 ZN C VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI222D0 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI18 ZN A2 net27 VSS nch w=0.195u l=0.06u
MI14 net39 C2 VSS VSS nch w=0.195u l=0.06u
MI15 net27 B1 net39 VSS nch w=0.195u l=0.06u
MI16 net27 B2 net39 VSS nch w=0.195u l=0.06u
MI17 ZN A1 net27 VSS nch w=0.195u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.195u l=0.06u
MI8 ZN C2 net46 VDD pch w=0.26u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.26u l=0.06u
MI13 ZN A1 net34 VDD pch w=0.26u l=0.06u
MI12 net34 A2 VDD VDD pch w=0.26u l=0.06u
MI9 ZN B2 net37 VDD pch w=0.26u l=0.06u
MI11 net37 B1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI222D1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
M_u3 ZN A2 net27 VSS nch w=0.39u l=0.06u
M_u2 ZN A1 net27 VSS nch w=0.39u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.39u l=0.06u
MU23 net39 C2 VSS VSS nch w=0.39u l=0.06u
M_u5 net27 B2 net39 VSS nch w=0.39u l=0.06u
M_u4 net27 B1 net39 VSS nch w=0.39u l=0.06u
MI4 net37 B1 VDD VDD pch w=0.52u l=0.06u
MI5 ZN B2 net37 VDD pch w=0.52u l=0.06u
MI6 ZN A1 net34 VDD pch w=0.52u l=0.06u
MI7 net34 A2 VDD VDD pch w=0.52u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.52u l=0.06u
MI3 ZN C2 net46 VDD pch w=0.52u l=0.06u
.ends
.subckt OAI222D2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI18 ZN A2 net27 VSS nch w=0.78u l=0.06u
MI27 net39 C2 VSS VSS nch w=0.78u l=0.06u
MI26 net27 B1 net39 VSS nch w=0.78u l=0.06u
MI25 net27 B2 net39 VSS nch w=0.78u l=0.06u
MI24 ZN A1 net27 VSS nch w=0.78u l=0.06u
MI28 net39 C1 VSS VSS nch w=0.78u l=0.06u
MI23_0 ZN A1 net53<0> VDD pch w=0.52u l=0.06u
MI23_1 ZN A1 net53<1> VDD pch w=0.52u l=0.06u
MI2_0 net65<0> C1 VDD VDD pch w=0.52u l=0.06u
MI2_1 net65<1> C1 VDD VDD pch w=0.52u l=0.06u
MI22_0 net53<0> A2 VDD VDD pch w=0.52u l=0.06u
MI22_1 net53<1> A2 VDD VDD pch w=0.52u l=0.06u
MI21_0 ZN B2 net59<0> VDD pch w=0.52u l=0.06u
MI21_1 ZN B2 net59<1> VDD pch w=0.52u l=0.06u
MI19_0 ZN C2 net65<0> VDD pch w=0.52u l=0.06u
MI19_1 ZN C2 net65<1> VDD pch w=0.52u l=0.06u
MI20_0 net59<0> B1 VDD VDD pch w=0.52u l=0.06u
MI20_1 net59<1> B1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI222D4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
M_u3 net44 A2 net27 VSS nch w=0.39u l=0.06u
M_u2 net44 A1 net27 VSS nch w=0.39u l=0.06u
MU25 net39 C1 VSS VSS nch w=0.39u l=0.06u
MU23 net39 C2 VSS VSS nch w=0.39u l=0.06u
M_u5 net27 B2 net39 VSS nch w=0.39u l=0.06u
M_u4 net27 B1 net39 VSS nch w=0.39u l=0.06u
MI11-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI12-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net33 net44 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 ZN net33 VSS VSS nch w=0.39u l=0.06u
MI4 net37 B1 VDD VDD pch w=0.52u l=0.06u
MI5 net44 B2 net37 VDD pch w=0.52u l=0.06u
MI6 net44 A1 net34 VDD pch w=0.52u l=0.06u
MI7 net34 A2 VDD VDD pch w=0.52u l=0.06u
MI2 net46 C1 VDD VDD pch w=0.52u l=0.06u
MI3 net44 C2 net46 VDD pch w=0.52u l=0.06u
MI11-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MI12-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net33 net44 VDD VDD pch w=0.52u l=0.06u
MI9-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
MI8-M_u3 ZN net33 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI222XD4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
M_u3 ZN A2 net27 VSS nch w=1.56u l=0.06u
MI18 ZN A1 net27 VSS nch w=1.56u l=0.06u
MI22 net39 C1 VSS VSS nch w=1.56u l=0.06u
MI21 net39 C2 VSS VSS nch w=1.56u l=0.06u
MI19 net27 B2 net39 VSS nch w=1.56u l=0.06u
MI20 net27 B1 net39 VSS nch w=1.56u l=0.06u
MI15 ZN B2 net37 VDD pch w=2.08u l=0.06u
MI14 net37 B1 VDD VDD pch w=2.08u l=0.06u
MI13 ZN A1 net34 VDD pch w=2.08u l=0.06u
MI7 net34 A2 VDD VDD pch w=2.08u l=0.06u
MI16 net46 C1 VDD VDD pch w=2.08u l=0.06u
MI17 ZN C2 net46 VDD pch w=2.08u l=0.06u
.ends
.subckt OAI22D0 A1 A2 B1 B2 ZN VDD VSS
MI9 ZN A1 net10 VSS nch w=0.195u l=0.06u
M_u4 net10 B2 VSS VSS nch w=0.195u l=0.06u
MI8 ZN A2 net10 VSS nch w=0.195u l=0.06u
MI7 net10 B1 VSS VSS nch w=0.195u l=0.06u
MU24 net30 B2 VDD VDD pch w=0.26u l=0.06u
MI6 ZN A1 net24 VDD pch w=0.26u l=0.06u
MI5 net24 A2 VDD VDD pch w=0.26u l=0.06u
MI4 ZN B1 net30 VDD pch w=0.26u l=0.06u
.ends
.subckt OAI22D1 A1 A2 B1 B2 ZN VDD VSS
M_u4 net10 B2 VSS VSS nch w=0.39u l=0.06u
M_u3 ZN A1 net10 VSS nch w=0.39u l=0.06u
M_u2 ZN A2 net10 VSS nch w=0.39u l=0.06u
M_u5 net10 B1 VSS VSS nch w=0.39u l=0.06u
MU24 net30 B2 VDD VDD pch w=0.52u l=0.06u
MI3 ZN A1 net24 VDD pch w=0.52u l=0.06u
MI2 net24 A2 VDD VDD pch w=0.52u l=0.06u
MI1 ZN B1 net30 VDD pch w=0.52u l=0.06u
.ends
.subckt OAI22D2 A1 A2 B1 B2 ZN VDD VSS
MI9 ZN A1 net10 VSS nch w=0.78u l=0.06u
M_u4 net10 B2 VSS VSS nch w=0.78u l=0.06u
MI8 ZN A2 net10 VSS nch w=0.78u l=0.06u
MI7 net10 B1 VSS VSS nch w=0.78u l=0.06u
MU24_0 net45<0> B2 VDD VDD pch w=0.52u l=0.06u
MU24_1 net45<1> B2 VDD VDD pch w=0.52u l=0.06u
MI6_0 net42<0> A2 VDD VDD pch w=0.52u l=0.06u
MI6_1 net42<1> A2 VDD VDD pch w=0.52u l=0.06u
MI5_0 ZN A1 net42<0> VDD pch w=0.52u l=0.06u
MI5_1 ZN A1 net42<1> VDD pch w=0.52u l=0.06u
MI4_0 ZN B1 net45<0> VDD pch w=0.52u l=0.06u
MI4_1 ZN B1 net45<1> VDD pch w=0.52u l=0.06u
.ends
.subckt OAI22D4 A1 A2 B1 B2 ZN VDD VSS
MI25 net034 B2 VSS VSS nch w=1.56u l=0.06u
MI24 net034 B1 VSS VSS nch w=1.56u l=0.06u
MI23 ZN A2 net034 VSS nch w=1.56u l=0.06u
MI16 ZN A1 net034 VSS nch w=1.56u l=0.06u
MI26 ZN A1 net045 VDD pch w=2.08u l=0.06u
MI27 net039 B2 VDD VDD pch w=2.08u l=0.06u
MI28 ZN B1 net039 VDD pch w=2.08u l=0.06u
MI18 net045 A2 VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI31D0 A1 A2 A3 B ZN VDD VSS
M_u5 VSS B net22 VSS nch w=0.195u l=0.06u
MI8 net22 A3 ZN VSS nch w=0.195u l=0.06u
MI7 net22 A2 ZN VSS nch w=0.195u l=0.06u
MI6 net22 A1 ZN VSS nch w=0.195u l=0.06u
MI3 net38 A1 VDD VDD pch w=0.26u l=0.06u
MI4 net35 A2 net38 VDD pch w=0.26u l=0.06u
MI5 ZN A3 net35 VDD pch w=0.26u l=0.06u
M_u11 ZN B VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI31D1 A1 A2 A3 B ZN VDD VSS
M_u5 VSS B net22 VSS nch w=0.39u l=0.06u
M_u3 ZN A3 net22 VSS nch w=0.39u l=0.06u
M_u2 ZN A2 net22 VSS nch w=0.39u l=0.06u
MU21 ZN A1 net22 VSS nch w=0.39u l=0.06u
MI0 net38 A1 VDD VDD pch w=0.52u l=0.06u
MI1 net35 A2 net38 VDD pch w=0.52u l=0.06u
MI2 ZN A3 net35 VDD pch w=0.52u l=0.06u
M_u11 ZN B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI31D2 A1 A2 A3 B ZN VDD VSS
MI14 VSS B net22 VSS nch w=0.78u l=0.06u
MI20 net22 A3 ZN VSS nch w=0.78u l=0.06u
MI19 net22 A2 ZN VSS nch w=0.78u l=0.06u
MI18 net22 A1 ZN VSS nch w=0.78u l=0.06u
MI3_0 net41<0> A1 VDD VDD pch w=0.52u l=0.06u
MI3_1 net41<1> A1 VDD VDD pch w=0.52u l=0.06u
MI15_0 net38<0> A2 net41<0> VDD pch w=0.52u l=0.06u
MI15_1 net38<1> A2 net41<1> VDD pch w=0.52u l=0.06u
MI16_0 ZN A3 net38<0> VDD pch w=0.52u l=0.06u
MI16_1 ZN A3 net38<1> VDD pch w=0.52u l=0.06u
MI17_0 ZN B VDD VDD pch w=0.52u l=0.06u
MI17_1 ZN B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI31D4 A1 A2 A3 B ZN VDD VSS
MI30 net033 B VSS VSS nch w=1.56u l=0.06u
MI15 ZN A3 net033 VSS nch w=1.56u l=0.06u
MI28 ZN A2 net033 VSS nch w=1.56u l=0.06u
MI29 ZN A1 net033 VSS nch w=1.56u l=0.06u
MI26 ZN A3 net041 VDD pch w=2.08u l=0.06u
MI25 net041 A2 net044 VDD pch w=2.08u l=0.06u
MI16 net044 A1 VDD VDD pch w=2.08u l=0.06u
MI27 ZN B VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI32D0 A1 A2 A3 B1 B2 ZN VDD VSS
MI9 ZN A1 net14 VSS nch w=0.195u l=0.06u
MI11 net14 B2 VSS VSS nch w=0.195u l=0.06u
MI12 net14 B1 VSS VSS nch w=0.195u l=0.06u
MI3 ZN A3 net14 VSS nch w=0.195u l=0.06u
MI8 ZN A2 net14 VSS nch w=0.195u l=0.06u
MI16-MI12 ZN B2 XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.26u l=0.06u
MI15-MI12 ZN A3 XI15-net11 VDD pch w=0.26u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.26u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI32D1 A1 A2 A3 B1 B2 ZN VDD VSS
MI0 net14 B2 VSS VSS nch w=0.39u l=0.06u
MI3 ZN A3 net14 VSS nch w=0.39u l=0.06u
MI2 ZN A2 net14 VSS nch w=0.39u l=0.06u
M_u4 net14 B1 VSS VSS nch w=0.39u l=0.06u
MI1 ZN A1 net14 VSS nch w=0.39u l=0.06u
MI16-MI12 ZN B2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15-MI12 ZN A3 XI15-net11 VDD pch w=0.52u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.52u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI32D2 A1 A2 A3 B1 B2 ZN VDD VSS
MI4 net14 B2 VSS VSS nch w=0.78u l=0.06u
MI7 ZN A3 net14 VSS nch w=0.78u l=0.06u
MI6 ZN A2 net14 VSS nch w=0.78u l=0.06u
M_u4 net14 B1 VSS VSS nch w=0.78u l=0.06u
MI5 ZN A1 net14 VSS nch w=0.78u l=0.06u
MI16_0-MI12 ZN B2 XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 ZN B2 XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15_0-MI12 ZN A3 XI15_0-net11 VDD pch w=0.52u l=0.06u
MI15_0-MI13 XI15_0-net11 A2 XI15_0-net18 VDD pch w=0.52u l=0.06u
MI15_0-MI15 XI15_0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MI15_1-MI12 ZN A3 XI15_1-net11 VDD pch w=0.52u l=0.06u
MI15_1-MI13 XI15_1-net11 A2 XI15_1-net18 VDD pch w=0.52u l=0.06u
MI15_1-MI15 XI15_1-net18 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI32D4 A1 A2 A3 B1 B2 ZN VDD VSS
MI0 net14 B2 VSS VSS nch w=0.39u l=0.06u
MI3 net40 A3 net14 VSS nch w=0.39u l=0.06u
MI2 net40 A2 net14 VSS nch w=0.39u l=0.06u
M_u4 net14 B1 VSS VSS nch w=0.39u l=0.06u
MI1 net40 A1 net14 VSS nch w=0.39u l=0.06u
MI6-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 net26 net40 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI16-MI12 net40 B2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15-MI12 net40 A3 XI15-net11 VDD pch w=0.52u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=0.52u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=0.52u l=0.06u
MI6-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI8-M_u3 net26 net40 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI32XD4 A1 A2 A3 B1 B2 ZN VDD VSS
MI19 net14 B1 VSS VSS nch w=1.56u l=0.06u
MI18 net14 B2 VSS VSS nch w=1.56u l=0.06u
MI3 ZN A3 net14 VSS nch w=1.56u l=0.06u
MI14 ZN A2 net14 VSS nch w=1.56u l=0.06u
MI17 ZN A1 net14 VSS nch w=1.56u l=0.06u
MI16_0-MI12 ZN B2 XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 ZN B2 XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI16_2-MI12 ZN B2 XI16_2-net11 VDD pch w=0.52u l=0.06u
MI16_2-MI13 XI16_2-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI16_3-MI12 ZN B2 XI16_3-net11 VDD pch w=0.52u l=0.06u
MI16_3-MI13 XI16_3-net11 B1 VDD VDD pch w=0.52u l=0.06u
MI15-MI12 ZN A3 XI15-net11 VDD pch w=2.08u l=0.06u
MI15-MI13 XI15-net11 A2 XI15-net18 VDD pch w=2.08u l=0.06u
MI15-MI15 XI15-net18 A1 VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OAI33D0 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI8 net15 B2 VSS VSS nch w=0.195u l=0.06u
MI6 net15 B1 VSS VSS nch w=0.195u l=0.06u
MI13 ZN A3 net15 VSS nch w=0.33u l=0.06u
MI12 ZN A2 net15 VSS nch w=0.33u l=0.06u
MI9 net15 B3 VSS VSS nch w=0.195u l=0.06u
MI11 ZN A1 net15 VSS nch w=0.195u l=0.06u
MI1-MI12 ZN B3 XI1-net11 VDD pch w=0.26u l=0.06u
MI1-MI13 XI1-net11 B2 XI1-net18 VDD pch w=0.26u l=0.06u
MI1-MI15 XI1-net18 B1 VDD VDD pch w=0.26u l=0.06u
MI7-MI12 ZN A3 XI7-net11 VDD pch w=0.26u l=0.06u
MI7-MI13 XI7-net11 A2 XI7-net18 VDD pch w=0.26u l=0.06u
MI7-MI15 XI7-net18 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OAI33D1 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI7 net15 B2 VSS VSS nch w=0.39u l=0.06u
MI8 net15 B1 VSS VSS nch w=0.39u l=0.06u
MI4 ZN A2 net15 VSS nch w=0.39u l=0.06u
MI5 ZN A3 net15 VSS nch w=0.39u l=0.06u
MI6 net15 B3 VSS VSS nch w=0.39u l=0.06u
MU21 ZN A1 net15 VSS nch w=0.39u l=0.06u
MI2-MI12 ZN B3 XI2-net11 VDD pch w=0.52u l=0.06u
MI2-MI13 XI2-net11 B2 XI2-net18 VDD pch w=0.52u l=0.06u
MI2-MI15 XI2-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI3-MI12 ZN A3 XI3-net11 VDD pch w=0.52u l=0.06u
MI3-MI13 XI3-net11 A2 XI3-net18 VDD pch w=0.52u l=0.06u
MI3-MI15 XI3-net18 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI33D2 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI16 net15 B2 VSS VSS nch w=0.78u l=0.06u
MI17 net15 B1 VSS VSS nch w=0.78u l=0.06u
MI13 ZN A2 net15 VSS nch w=0.78u l=0.06u
MI5 ZN A3 net15 VSS nch w=0.78u l=0.06u
MI15 net15 B3 VSS VSS nch w=0.78u l=0.06u
MI14 ZN A1 net15 VSS nch w=0.78u l=0.06u
MI11_0-MI12 ZN B3 XI11_0-net11 VDD pch w=0.52u l=0.06u
MI11_0-MI13 XI11_0-net11 B2 XI11_0-net18 VDD pch w=0.52u l=0.06u
MI11_0-MI15 XI11_0-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI11_1-MI12 ZN B3 XI11_1-net11 VDD pch w=0.52u l=0.06u
MI11_1-MI13 XI11_1-net11 B2 XI11_1-net18 VDD pch w=0.52u l=0.06u
MI11_1-MI15 XI11_1-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI12_0-MI12 ZN A3 XI12_0-net11 VDD pch w=0.52u l=0.06u
MI12_0-MI13 XI12_0-net11 A2 XI12_0-net18 VDD pch w=0.52u l=0.06u
MI12_0-MI15 XI12_0-net18 A1 VDD VDD pch w=0.52u l=0.06u
MI12_1-MI12 ZN A3 XI12_1-net11 VDD pch w=0.52u l=0.06u
MI12_1-MI13 XI12_1-net11 A2 XI12_1-net18 VDD pch w=0.52u l=0.06u
MI12_1-MI15 XI12_1-net18 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI33D4 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI18 net15 B2 VSS VSS nch w=0.39u l=0.06u
MI19 net15 B1 VSS VSS nch w=0.39u l=0.06u
MI14 net48 A2 net15 VSS nch w=0.39u l=0.06u
MI5 net48 A3 net15 VSS nch w=0.39u l=0.06u
MI17 net15 B3 VSS VSS nch w=0.39u l=0.06u
MI16 net48 A1 net15 VSS nch w=0.39u l=0.06u
MI12-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net28 net48 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI12-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net28 net48 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI9-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI2-MI12 net48 B3 XI2-net11 VDD pch w=0.52u l=0.06u
MI2-MI13 XI2-net11 B2 XI2-net18 VDD pch w=0.52u l=0.06u
MI2-MI15 XI2-net18 B1 VDD VDD pch w=0.52u l=0.06u
MI3-MI12 net48 A3 XI3-net11 VDD pch w=0.52u l=0.06u
MI3-MI13 XI3-net11 A2 XI3-net18 VDD pch w=0.52u l=0.06u
MI3-MI15 XI3-net18 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OAI33XD4 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI24 net15 B2 VSS VSS nch w=1.56u l=0.06u
MI23 net15 B3 VSS VSS nch w=1.56u l=0.06u
MI21 ZN A2 net15 VSS nch w=1.56u l=0.06u
MI5 ZN A3 net15 VSS nch w=1.56u l=0.06u
MI25 net15 B1 VSS VSS nch w=1.56u l=0.06u
MI22 ZN A1 net15 VSS nch w=1.56u l=0.06u
MI14-MI12 ZN B3 XI14-net11 VDD pch w=2.08u l=0.06u
MI14-MI13 XI14-net11 B2 XI14-net18 VDD pch w=2.08u l=0.06u
MI14-MI15 XI14-net18 B1 VDD VDD pch w=2.08u l=0.06u
MI20-MI12 ZN A3 XI20-net11 VDD pch w=2.08u l=0.06u
MI20-MI13 XI20-net11 A2 XI20-net18 VDD pch w=2.08u l=0.06u
MI20-MI15 XI20-net18 A1 VDD VDD pch w=2.08u l=0.06u
.ends
.subckt OD25DCAP16 VDD VSS
M_u2 VSS VDD VSS VSS nch_25 w=0.53u l=1.41u
.ends
.subckt OD25DCAP32 VDD VSS
MI1 VSS VDD VSS VSS nch_25 w=0.53u l=2.15u
M_u2 VSS VDD VSS VSS nch_25 w=0.53u l=2.15u
.ends
.subckt OD25DCAP64 VDD VSS
MI3 VSS VDD VSS VSS nch_25 w=0.53u l=2.52u
MI4 VSS VDD VSS VSS nch_25 w=0.53u l=2.52u
MI2 VSS VDD VSS VSS nch_25 w=0.53u l=2.52u
M_u2 VSS VDD VSS VSS nch_25 w=0.53u l=2.52u
.ends
.subckt OR2D0 A1 A2 Z VDD VSS
MU1-M_u2 Z net7 VSS VSS nch w=0.195u l=0.06u
M_u7-M_u4 net7 A1 VSS VSS nch w=0.195u l=0.06u
M_u7-M_u3 net7 A2 VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 Z net7 VDD VDD pch w=0.26u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.26u l=0.06u
M_u7-M_u2 net7 A1 X_u7-net8 VDD pch w=0.26u l=0.06u
.ends
.subckt OR2D1 A1 A2 Z VDD VSS
MU1-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u4 net7 A1 VSS VSS nch w=0.195u l=0.06u
M_u7-M_u3 net7 A2 VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u2 net7 A1 X_u7-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt OR2D2 A1 A2 Z VDD VSS
MU1_0-M_u2 Z net9 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net9 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u4 net9 A1 VSS VSS nch w=0.195u l=0.06u
M_u7-M_u3 net9 A2 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u3 Z net9 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net9 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u2 net9 A1 X_u7-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt OR2D4 A1 A2 Z VDD VSS
MU1_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u7_0-M_u4 p0 A1 VSS VSS nch w=0.195u l=0.06u
M_u7_0-M_u3 p0 A2 VSS VSS nch w=0.195u l=0.06u
M_u7_1-M_u4 p0 A1 VSS VSS nch w=0.195u l=0.06u
M_u7_1-M_u3 p0 A2 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u1 X_u7_0-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u2 p0 A1 X_u7_0-net8 VDD pch w=0.52u l=0.06u
M_u7_1-M_u1 X_u7_1-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7_1-M_u2 p0 A1 X_u7_1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt OR2D8 A1 A2 Z VDD VSS
MU1_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_0-M_u4 n0 A1 VSS VSS nch w=0.195u l=0.06u
M_u7_0-M_u3 n0 A2 VSS VSS nch w=0.195u l=0.06u
M_u7_1-M_u4 n0 A1 VSS VSS nch w=0.195u l=0.06u
M_u7_1-M_u3 n0 A2 VSS VSS nch w=0.195u l=0.06u
M_u7_2-M_u4 n0 A1 VSS VSS nch w=0.195u l=0.06u
M_u7_2-M_u3 n0 A2 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u1 X_u7_0-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u2 n0 A1 X_u7_0-net8 VDD pch w=0.52u l=0.06u
M_u7_1-M_u1 X_u7_1-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7_1-M_u2 n0 A1 X_u7_1-net8 VDD pch w=0.52u l=0.06u
M_u7_2-M_u1 X_u7_2-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7_2-M_u2 n0 A1 X_u7_2-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt OR2XD1 A1 A2 Z VDD VSS
MU1-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u4 net7 A1 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u3 net7 A2 VSS VSS nch w=0.39u l=0.06u
MU1-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u2 net7 A1 X_u7-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt OR3D0 A1 A2 A3 Z VDD VSS
M_u4-M_u2 Z net7 VSS VSS nch w=0.195u l=0.06u
MU42-M_u6 net7 A3 VSS VSS nch w=0.195u l=0.06u
MU42-M_u5 net7 A2 VSS VSS nch w=0.195u l=0.06u
MU42-M_u4 net7 A1 VSS VSS nch w=0.195u l=0.06u
M_u4-M_u3 Z net7 VDD VDD pch w=0.26u l=0.06u
MU42-M_u1 XU42-net9 A1 VDD VDD pch w=0.26u l=0.06u
MU42-M_u2 XU42-net12 A2 XU42-net9 VDD pch w=0.26u l=0.06u
MU42-M_u3 net7 A3 XU42-net12 VDD pch w=0.26u l=0.06u
.ends
.subckt OR3D1 A1 A2 A3 Z VDD VSS
M_u4-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
MU42-M_u6 net7 A3 VSS VSS nch w=0.195u l=0.06u
MU42-M_u5 net7 A2 VSS VSS nch w=0.195u l=0.06u
MU42-M_u4 net7 A1 VSS VSS nch w=0.195u l=0.06u
M_u4-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
MU42-M_u1 XU42-net9 A1 VDD VDD pch w=0.52u l=0.06u
MU42-M_u2 XU42-net12 A2 XU42-net9 VDD pch w=0.52u l=0.06u
MU42-M_u3 net7 A3 XU42-net12 VDD pch w=0.52u l=0.06u
.ends
.subckt OR3D2 A1 A2 A3 Z VDD VSS
M_u4_0-M_u2 Z net12 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z net12 VSS VSS nch w=0.39u l=0.06u
MU42-M_u6 net12 A3 VSS VSS nch w=0.195u l=0.06u
MU42-M_u5 net12 A2 VSS VSS nch w=0.195u l=0.06u
MU42-M_u4 net12 A1 VSS VSS nch w=0.195u l=0.06u
M_u4_0-M_u3 Z net12 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z net12 VDD VDD pch w=0.52u l=0.06u
MU42-M_u1 XU42-net9 A1 VDD VDD pch w=0.52u l=0.06u
MU42-M_u2 XU42-net12 A2 XU42-net9 VDD pch w=0.52u l=0.06u
MU42-M_u3 net12 A3 XU42-net12 VDD pch w=0.52u l=0.06u
.ends
.subckt OR3D4 A1 A2 A3 Z VDD VSS
M_u4_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU42_0-M_u6 p0 A3 VSS VSS nch w=0.195u l=0.06u
MU42_0-M_u5 p0 A2 VSS VSS nch w=0.195u l=0.06u
MU42_0-M_u4 p0 A1 VSS VSS nch w=0.195u l=0.06u
MU42_1-M_u6 p0 A3 VSS VSS nch w=0.195u l=0.06u
MU42_1-M_u5 p0 A2 VSS VSS nch w=0.195u l=0.06u
MU42_1-M_u4 p0 A1 VSS VSS nch w=0.195u l=0.06u
M_u4_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU42_0-M_u1 XU42_0-net9 A1 VDD VDD pch w=0.52u l=0.06u
MU42_0-M_u2 XU42_0-net12 A2 XU42_0-net9 VDD pch w=0.52u l=0.06u
MU42_0-M_u3 p0 A3 XU42_0-net12 VDD pch w=0.52u l=0.06u
MU42_1-M_u1 XU42_1-net9 A1 VDD VDD pch w=0.52u l=0.06u
MU42_1-M_u2 XU42_1-net12 A2 XU42_1-net9 VDD pch w=0.52u l=0.06u
MU42_1-M_u3 p0 A3 XU42_1-net12 VDD pch w=0.52u l=0.06u
.ends
.subckt OR3D8 A1 A2 A3 Z VDD VSS
M_u4_0-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_2-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_3-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_4-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_5-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_6-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
M_u4_7-M_u2 Z net13 VSS VSS nch w=0.39u l=0.06u
MU42-M_u6 net13 A1 VSS VSS nch w=0.585u l=0.06u
MU42-M_u5 net13 A2 VSS VSS nch w=0.585u l=0.06u
MU42-M_u4 net13 A3 VSS VSS nch w=0.585u l=0.06u
M_u4_0-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_2-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_3-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_4-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_5-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_6-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
M_u4_7-M_u3 Z net13 VDD VDD pch w=0.52u l=0.06u
MU42-M_u1 XU42-net9 A3 VDD VDD pch w=1.56u l=0.06u
MU42-M_u2 XU42-net12 A2 XU42-net9 VDD pch w=1.56u l=0.06u
MU42-M_u3 net13 A1 XU42-net12 VDD pch w=1.56u l=0.06u
.ends
.subckt OR3XD1 A1 A2 A3 Z VDD VSS
M_u4-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
MU42-M_u6 net7 A3 VSS VSS nch w=0.39u l=0.06u
MU42-M_u5 net7 A2 VSS VSS nch w=0.39u l=0.06u
MU42-M_u4 net7 A1 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
MU42-M_u1 XU42-net9 A1 VDD VDD pch w=0.52u l=0.06u
MU42-M_u2 XU42-net12 A2 XU42-net9 VDD pch w=0.52u l=0.06u
MU42-M_u3 net7 A3 XU42-net12 VDD pch w=0.52u l=0.06u
.ends
.subckt OR4D0 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net14 VSS VSS nch w=0.195u l=0.06u
MU8-M_u4 net14 A1 VSS VSS nch w=0.195u l=0.06u
MU8-M_u3 net14 A2 VSS VSS nch w=0.195u l=0.06u
MU8-M_u5 net14 A3 VSS VSS nch w=0.195u l=0.06u
MU8-M_u8 net14 A4 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net14 VDD VDD pch w=0.26u l=0.06u
MU8-M_u7 net14 A4 XU8-net7 VDD pch w=0.26u l=0.06u
MU8-M_u6 XU8-net7 A3 XU8-net10 VDD pch w=0.26u l=0.06u
MU8-M_u2 XU8-net10 A2 XU8-net13 VDD pch w=0.26u l=0.06u
MU8-M_u1 XU8-net13 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt OR4D1 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MU8-M_u4 net14 A1 VSS VSS nch w=0.195u l=0.06u
MU8-M_u3 net14 A2 VSS VSS nch w=0.195u l=0.06u
MU8-M_u5 net14 A3 VSS VSS nch w=0.195u l=0.06u
MU8-M_u8 net14 A4 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
MU8-M_u7 net14 A4 XU8-net7 VDD pch w=0.52u l=0.06u
MU8-M_u6 XU8-net7 A3 XU8-net10 VDD pch w=0.52u l=0.06u
MU8-M_u2 XU8-net10 A2 XU8-net13 VDD pch w=0.52u l=0.06u
MU8-M_u1 XU8-net13 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OR4D2 A1 A2 A3 A4 Z VDD VSS
M_u3_0-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MU8-M_u4 net14 A1 VSS VSS nch w=0.195u l=0.06u
MU8-M_u3 net14 A2 VSS VSS nch w=0.195u l=0.06u
MU8-M_u5 net14 A3 VSS VSS nch w=0.195u l=0.06u
MU8-M_u8 net14 A4 VSS VSS nch w=0.195u l=0.06u
M_u3_0-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
MU8-M_u7 net14 A4 XU8-net7 VDD pch w=0.52u l=0.06u
MU8-M_u6 XU8-net7 A3 XU8-net10 VDD pch w=0.52u l=0.06u
MU8-M_u2 XU8-net10 A2 XU8-net13 VDD pch w=0.52u l=0.06u
MU8-M_u1 XU8-net13 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OR4D4 A1 A2 A3 A4 Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u4 p0 A1 VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u3 p0 A2 VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u5 p0 A3 VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u8 p0 A4 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u4 p0 A1 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u3 p0 A2 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u5 p0 A3 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u8 p0 A4 VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU8_0-M_u7 p0 A4 XU8_0-net7 VDD pch w=0.52u l=0.06u
MU8_0-M_u6 XU8_0-net7 A3 XU8_0-net10 VDD pch w=0.52u l=0.06u
MU8_0-M_u2 XU8_0-net10 A2 XU8_0-net13 VDD pch w=0.52u l=0.06u
MU8_0-M_u1 XU8_0-net13 A1 VDD VDD pch w=0.52u l=0.06u
MU8_1-M_u7 p0 A4 XU8_1-net7 VDD pch w=0.52u l=0.06u
MU8_1-M_u6 XU8_1-net7 A3 XU8_1-net10 VDD pch w=0.52u l=0.06u
MU8_1-M_u2 XU8_1-net10 A2 XU8_1-net13 VDD pch w=0.52u l=0.06u
MU8_1-M_u1 XU8_1-net13 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OR4D8 A1 A2 A3 A4 Z VDD VSS
M_u3_0-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_4-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_5-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_6-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
M_u3_7-M_u2 Z net030 VSS VSS nch w=0.39u l=0.06u
MI24 net030 A3 VSS VSS nch w=1.17u l=0.06u
MI25 net030 A4 VSS VSS nch w=1.17u l=0.06u
MI6 net030 A1 VSS VSS nch w=1.17u l=0.06u
MI23 net030 A2 VSS VSS nch w=1.17u l=0.06u
M_u3_0-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_4-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_5-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_6-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
M_u3_7-M_u3 Z net030 VDD VDD pch w=0.52u l=0.06u
MI14 net030 A1 net32 VDD pch w=0.52u l=0.06u
MI13 net32 A2 net35 VDD pch w=0.52u l=0.06u
MI2 net35 A3 net38 VDD pch w=0.52u l=0.06u
MI3 net38 A4 VDD VDD pch w=0.52u l=0.06u
MI7 net38 A4 VDD VDD pch w=0.52u l=0.06u
MI8 net030 A1 net32 VDD pch w=0.52u l=0.06u
MI9 net32 A2 net35 VDD pch w=0.52u l=0.06u
MI11 net35 A3 net38 VDD pch w=0.52u l=0.06u
MI12 net35 A3 net38 VDD pch w=0.52u l=0.06u
MI16 net32 A2 net35 VDD pch w=0.52u l=0.06u
MI17 net030 A1 net32 VDD pch w=0.52u l=0.06u
MI18 net38 A4 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt OR4XD1 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
MU8-M_u4 net14 A1 VSS VSS nch w=0.39u l=0.06u
MU8-M_u3 net14 A2 VSS VSS nch w=0.39u l=0.06u
MU8-M_u5 net14 A3 VSS VSS nch w=0.39u l=0.06u
MU8-M_u8 net14 A4 VSS VSS nch w=0.39u l=0.06u
M_u3-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
MU8-M_u7 net14 A4 XU8-net7 VDD pch w=0.52u l=0.06u
MU8-M_u6 XU8-net7 A3 XU8-net10 VDD pch w=0.52u l=0.06u
MU8-M_u2 XU8-net10 A2 XU8-net13 VDD pch w=0.52u l=0.06u
MU8-M_u1 XU8-net13 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFCND0 SI D SE CP CDN Q QN VDD VSS
MI150 net62 INCPB net163 VSS nch w=0.15u l=0.06u
MI149 d1 INCP net163 VSS nch w=0.2u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 D net093 VSS nch w=0.26u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net093 net0105 VSS VSS nch w=0.26u l=0.06u
MI166-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.195u l=0.06u
MI152-M_u2 Q net066 VSS VSS nch w=0.195u l=0.06u
MI173-M_u2 net62 net066 VSS VSS nch w=0.195u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net0105 SE VSS VSS nch w=0.15u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.35u l=0.06u
MI158-M_u3 net066 net163 XI158-net6 VSS nch w=0.35u l=0.06u
MI166-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.26u l=0.06u
MI152-M_u3 Q net066 VDD VDD pch w=0.26u l=0.06u
MI173-M_u3 net62 net066 VDD VDD pch w=0.26u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net0105 SE VDD VDD pch w=0.2u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI155 net62 INCP net163 VDD pch w=0.15u l=0.06u
MI170 net132 D net69 VDD pch w=0.33u l=0.06u
MI163 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net0105 net142 VDD pch w=0.15u l=0.06u
MI73 net69 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.15u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB net163 VDD pch w=0.29u l=0.06u
MI158-M_u2 net066 CDN VDD VDD pch w=0.44u l=0.06u
MI158-M_u1 net066 net163 VDD VDD pch w=0.44u l=0.06u
.ends
.subckt SDFCND1 SI D SE CP CDN Q QN VDD VSS
MI150 net62 INCPB net163 VSS nch w=0.15u l=0.06u
MI149 d1 INCP net163 VSS nch w=0.2u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI166-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q net0140 VSS VSS nch w=0.39u l=0.06u
MI174-M_u2 net62 net0140 VSS VSS nch w=0.23u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.35u l=0.06u
MI158-M_u3 net0140 net163 XI158-net6 VSS nch w=0.35u l=0.06u
MI166-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q net0140 VDD VDD pch w=0.52u l=0.06u
MI174-M_u3 net62 net0140 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI155 net62 INCP net163 VDD pch w=0.16u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI163 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB net163 VDD pch w=0.29u l=0.06u
MI158-M_u2 net0140 CDN VDD VDD pch w=0.44u l=0.06u
MI158-M_u1 net0140 net163 VDD VDD pch w=0.44u l=0.06u
.ends
.subckt SDFCND2 SI D SE CP CDN Q QN VDD VSS
MI150 net62 INCPB d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI178-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI179-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI171-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI172-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI176-M_u2 net62 d3 VSS VSS nch w=0.21u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158_0-M_u4 XI158_0-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_0-M_u3 d3 d2 XI158_0-net6 VSS nch w=0.23u l=0.06u
MI158_1-M_u4 XI158_1-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_1-M_u3 d3 d2 XI158_1-net6 VSS nch w=0.23u l=0.06u
MI178-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI179-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI171-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI172-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI176-M_u3 net62 d3 VDD VDD pch w=0.345u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI155 net62 INCP d2 VDD pch w=0.15u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI175 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI174 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB d2 VDD pch w=0.29u l=0.06u
MI158_0-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI158_0-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
MI158_1-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI158_1-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
.ends
.subckt SDFCND4 SI D SE CP CDN Q QN VDD VSS
MI150 net62 INCPB d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI167-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI168-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI183-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI153-M_u2 net62 d3 VSS VSS nch w=0.6u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI176-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI178-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI182-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI179-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158-M_u3 d3 d2 XI158-net6 VSS nch w=0.23u l=0.06u
MI173-M_u4 XI173-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI173-M_u3 d3 d2 XI173-net6 VSS nch w=0.23u l=0.06u
MI167-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI168-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI183-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI153-M_u3 net62 d3 VDD VDD pch w=0.865u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI176-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI178-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI182-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI179-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI155 net62 INCP d2 VDD pch w=0.15u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI175 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI174 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB d2 VDD pch w=0.29u l=0.06u
MI158-M_u2 d3 CDN VDD VDD pch w=0.47u l=0.06u
MI158-M_u1 d3 d2 VDD VDD pch w=0.47u l=0.06u
MI173-M_u2 d3 CDN VDD VDD pch w=0.47u l=0.06u
MI173-M_u1 d3 d2 VDD VDD pch w=0.47u l=0.06u
.ends
.subckt SDFCNQD0 SI D SE CP CDN Q VDD VSS
MI166-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net0111 SE VSS VSS nch w=0.15u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI26 net161 d3 VSS VSS nch w=0.15u l=0.06u
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI29 d2 INCPB net161 VSS nch w=0.15u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 D net0103 VSS nch w=0.26u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net0103 net0111 VSS VSS nch w=0.26u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.33u l=0.06u
MI158-M_u3 d3 d2 XI158-net6 VSS nch w=0.33u l=0.06u
MI166-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net0111 SE VDD VDD pch w=0.2u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI28 d2 INCP net155 VDD pch w=0.15u l=0.06u
MI170 net132 D net69 VDD pch w=0.33u l=0.06u
MI163 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI24 net155 d3 VDD VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net0111 net142 VDD pch w=0.15u l=0.06u
MI73 net69 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.15u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB d2 VDD pch w=0.29u l=0.06u
MI158-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFCNQD1 SI D SE CP CDN Q VDD VSS
MI166-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI26 net161 d3 VSS VSS nch w=0.15u l=0.06u
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI29 d2 INCPB net161 VSS nch w=0.15u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.325u l=0.06u
MI158-M_u3 d3 d2 XI158-net6 VSS nch w=0.325u l=0.06u
MI166-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI28 d2 INCP net155 VDD pch w=0.15u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI172 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI24 net155 d3 VDD VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI171 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB d2 VDD pch w=0.29u l=0.06u
MI158-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFCNQD2 SI D SE CP CDN Q VDD VSS
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI26 net078 d3 VSS VSS nch w=0.15u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI29 d2 INCPB net078 VSS nch w=0.15u l=0.06u
MI178-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI171-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI172-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158_0-M_u4 XI158_0-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_0-M_u3 d3 d2 XI158_0-net6 VSS nch w=0.23u l=0.06u
MI158_1-M_u4 XI158_1-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_1-M_u3 d3 d2 XI158_1-net6 VSS nch w=0.23u l=0.06u
MI178-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI171-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI172-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI28 d2 INCP net0119 VDD pch w=0.15u l=0.06u
MI24 net0119 d3 VDD VDD pch w=0.15u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI175 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI174 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 INCPB d2 VDD pch w=0.29u l=0.06u
MI158_0-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158_0-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI158_1-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158_1-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFCNQD4 SI D SE CP CDN Q VDD VSS
MI149 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI26 net090 d3 VSS VSS nch w=0.15u l=0.06u
MI165 net63 CDN VSS VSS nch w=0.15u l=0.06u
MI164 net82 d1 net63 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net82 VSS nch w=0.15u l=0.06u
MI169 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI77 d0 net0112 net177 VSS nch w=0.3u l=0.06u
MI161 net67 SI VSS VSS nch w=0.15u l=0.06u
MI160 net177 SE net67 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI29 d2 net0112 net090 VSS nch w=0.15u l=0.06u
MI167-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI185-M_u2 net0112 CP VSS VSS nch w=0.39u l=0.06u
MI186-M_u2 INCP net0112 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI176-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158_0-M_u4 XI158_0-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_0-M_u3 d3 d2 XI158_0-net6 VSS nch w=0.23u l=0.06u
MI158_1-M_u4 XI158_1-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158_1-M_u3 d3 d2 XI158_1-net6 VSS nch w=0.23u l=0.06u
MI167-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI185-M_u3 net0112 CP VDD VDD pch w=0.52u l=0.06u
MI186-M_u3 INCP net0112 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI176-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI28 d2 INCP net0135 VDD pch w=0.15u l=0.06u
MI24 net0135 d3 VDD VDD pch w=0.15u l=0.06u
MI170 net132 SE net69 VDD pch w=0.44u l=0.06u
MI175 d0 net0112 net166 VDD pch w=0.15u l=0.06u
MI162 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net132 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net132 VDD pch w=0.29u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI174 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 net0112 d2 VDD pch w=0.29u l=0.06u
MI158_0-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158_0-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI158_1-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI158_1-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFCSND0 SI D SE CP CDN SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 D net0102 VSS nch w=0.26u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net0102 net0108 VSS VSS nch w=0.26u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net0108 SE VSS VSS nch w=0.15u l=0.06u
MI104-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net0108 SE VDD VDD pch w=0.2u l=0.06u
MI104-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI102 net104 D net107 VDD pch w=0.33u l=0.06u
MI45 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net0108 net148 VDD pch w=0.15u l=0.06u
MI73 net107 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net148 SI VDD VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSND1 SI D SE CP CDN SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI102 net104 SE net107 VDD pch w=0.44u l=0.06u
MI104 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSND2 SI D SE CP CDN SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.35u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI100-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI106-M_u4 XI106-net6 d3 VSS VSS nch w=0.35u l=0.06u
MI106-M_u3 d4 SDN XI106-net6 VSS nch w=0.35u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI100-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI108-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI102 net104 SE net107 VDD pch w=0.44u l=0.06u
MI45 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI106-M_u2 d4 d3 VDD VDD pch w=0.38u l=0.06u
MI106-M_u1 d4 SDN VDD VDD pch w=0.38u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSND4 SI D SE CP CDN SDN Q QN VDD VSS
MI91 d4 net0120 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.35u l=0.06u
MI77 d0 net0120 net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI114-M_u2 INCP net0120 VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI100-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI107-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI109-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI110-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI113-M_u2 net0120 CP VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI106-M_u4 XI106-net6 d3 VSS VSS nch w=0.35u l=0.06u
MI106-M_u3 d4 SDN XI106-net6 VSS nch w=0.35u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.17u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.17u l=0.06u
MI105-M_u4 XI105-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI105-M_u3 d3 CDN XI105-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI114-M_u3 INCP net0120 VDD VDD pch w=0.52u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI100-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI107-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI108-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI109-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI110-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI113-M_u3 net0120 CP VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI102 net104 SE net107 VDD pch w=0.44u l=0.06u
MI45 d0 net0120 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 net0120 d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI106-M_u2 d4 d3 VDD VDD pch w=0.38u l=0.06u
MI106-M_u1 d4 SDN VDD VDD pch w=0.38u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI105-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI105-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSNQD0 SI D SE CP CDN SDN Q VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 D net0102 VSS nch w=0.26u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net0102 net0108 VSS VSS nch w=0.26u l=0.06u
MI105-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net0108 SE VSS VSS nch w=0.15u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.34u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.34u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI105-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net0108 SE VDD VDD pch w=0.2u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI102 net104 D net107 VDD pch w=0.33u l=0.06u
MI45 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net0108 net148 VDD pch w=0.15u l=0.06u
MI73 net107 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net148 SI VDD VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSNQD1 SI D SE CP CDN SDN Q VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.39u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI103-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.2u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI103-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI102 net104 SE net107 VDD pch w=0.4u l=0.06u
MI105 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.49u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.32u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.2u l=0.06u
MI104 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.15u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.15u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSNQD2 SI D SE CP CDN SDN Q VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.39u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI107-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI106-M_u4 XI106-net6 d2 VSS VSS nch w=0.17u l=0.06u
MI106-M_u3 d3 CDN XI106-net6 VSS nch w=0.17u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.15u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI107-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI102 net104 SE net107 VDD pch w=0.4u l=0.06u
MI45 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.49u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.32u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI106-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI106-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.15u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.15u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFCSNQD4 SI D SE CP CDN SDN Q VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net86 VSS nch w=0.15u l=0.06u
MI101 net177 net120 net107 VSS nch w=0.39u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.3u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net107 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI104-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.15u l=0.06u
MI106-M_u4 XI106-net6 d2 VSS VSS nch w=0.19u l=0.06u
MI106-M_u3 d3 CDN XI106-net6 VSS nch w=0.19u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.32u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.32u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI108-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI104-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI102 net104 SE net107 VDD pch w=0.4u l=0.06u
MI45 d0 INCPB net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net107 D VDD VDD pch w=0.49u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.32u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.15u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.15u l=0.06u
MI106-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI106-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFD0 SI D SE CP Q QN VDD VSS
MI39 net37 D net64 VSS nch w=0.26u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 INCPB d2 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.16u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 net57 VSS VSS nch w=0.26u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.195u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI41-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.26u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI41-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCP d2 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net0111 SE VDD VDD pch w=0.33u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 D net0111 VDD pch w=0.33u l=0.06u
.ends
.subckt SDFD1 SI D SE CP Q QN VDD VSS
MI39 net37 net57 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 INCPB d2 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.18u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.195u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI41-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=0.26u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI41-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCP d2 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFD2 SI D SE CP Q QN VDD VSS
MI39 net37 net57 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 INCPB d2 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.16u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI43-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI43-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCP d2 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFD4 SI D SE CP Q QN VDD VSS
MI39 net37 net0139 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 INCPB d2 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.19u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.78u l=0.06u
MI44-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI45-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI46-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI47-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net0139 SE VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=1.04u l=0.06u
MI44-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI45-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI46-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI47-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net0139 SE VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCP d2 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net0139 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFKCND0 SI D SE CP CN Q QN VDD VSS
MI138-M_u2 QN net69 VSS VSS nch w=0.195u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI139-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.15u l=0.06u
MI140-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI142-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.195u l=0.06u
MI80 net135 D VSS VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 QN net69 VDD VDD pch w=0.26u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI139-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.2u l=0.06u
MI140-M_u3 net93 net155 VDD VDD pch w=0.295u l=0.06u
MI142-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.2u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.495u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.26u l=0.06u
MI77 VDD D net132 VDD pch w=0.26u l=0.06u
.ends
.subckt SDFKCND1 SI D SE CP CN Q QN VDD VSS
MI138-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI143-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI141-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.33u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.39u l=0.06u
MI80 net135 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI144-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI143-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI141-M_u3 net93 net155 VDD VDD pch w=0.295u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.495u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCND2 SI D SE CP CN Q QN VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI142-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 p0 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.33u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB p0 VSS nch w=0.27u l=0.06u
MI101 p0 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.39u l=0.06u
MI80 net135 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI142-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 p0 VDD VDD pch w=0.295u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.495u l=0.06u
MI127 net109 INCP p0 VDD pch w=0.34u l=0.06u
MI99 p0 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCND4 SI D SE CP CN Q QN VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI145-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI49-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI42_1-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI141-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 net69 net105 VSS VSS nch w=0.235u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI142-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI143-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI144-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.565u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.33u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.39u l=0.06u
MI80 net135 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI145-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI42_1-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI141-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 net69 net105 VDD VDD pch w=0.315u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI142-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI143-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI144-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCNQD0 SI D SE CP CN Q VDD VSS
MI112 net93 INCP net71 VSS nch w=0.18u l=0.06u
MI122 net068 Q VSS VSS nch w=0.15u l=0.06u
MI64 net76 net85 VSS VSS nch w=0.195u l=0.06u
MI65 net146 net81 net76 VSS nch w=0.195u l=0.06u
MI62 net146 SE net101 VSS nch w=0.15u l=0.06u
MI121 net71 INCPB net068 VSS nch w=0.15u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI83 net155 INCPB net146 VSS nch w=0.23u l=0.06u
MI63 net101 net0106 VSS VSS nch w=0.15u l=0.06u
MI79 net81 CN net135 VSS nch w=0.15u l=0.06u
MI80 net135 D VSS VSS nch w=0.15u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net85 SE VSS VSS nch w=0.195u l=0.06u
MI126-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI127-M_u2 net0106 SI VSS VSS nch w=0.15u l=0.06u
MI129-M_u2 Q net71 VSS VSS nch w=0.39u l=0.06u
MI128-M_u2 net93 net155 VSS VSS nch w=0.34u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI45-M_u3 net85 SE VDD VDD pch w=0.29u l=0.06u
MI126-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI127-M_u3 net0106 SI VDD VDD pch w=0.15u l=0.06u
MI129-M_u3 Q net71 VDD VDD pch w=0.52u l=0.06u
MI128-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI50 net127 SE VDD VDD pch w=0.235u l=0.06u
MI82 net155 INCP net117 VDD pch w=0.3u l=0.06u
MI123 net71 INCP net0116 VDD pch w=0.15u l=0.06u
MI53 net117 net85 net139 VDD pch w=0.15u l=0.06u
MI51 net117 net81 net127 VDD pch w=0.235u l=0.06u
MI52 net139 net0106 VDD VDD pch w=0.15u l=0.06u
MI124 net0116 Q VDD VDD pch w=0.15u l=0.06u
MI119 net93 INCPB net71 VDD pch w=0.43u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI74 VDD CN net81 VDD pch w=0.2u l=0.06u
MI77 VDD D net81 VDD pch w=0.2u l=0.06u
.ends
.subckt SDFKCNQD1 SI D SE CP CN Q VDD VSS
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI139-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI140-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.33u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.39u l=0.06u
MI80 net135 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI139-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.295u l=0.06u
MI140-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.495u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCNQD2 SI D SE CP CN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI140-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.33u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.39u l=0.06u
MI80 net135 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.295u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.495u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCNQD4 SI D SE CP CN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.24u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI42_1-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI142-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.565u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.35u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 CN net135 VSS nch w=0.41u l=0.06u
MI80 net135 D VSS VSS nch w=0.41u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.52u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI42_1-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI142-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.51u l=0.06u
MI77 VDD D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKCSND0 SI D SE CP CN SN Q QN VDD VSS
MI140-M_u2 QN net69 VSS VSS nch w=0.195u l=0.06u
MI142-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.15u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI143-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI72-M_u2 net120 SN VSS VSS nch w=0.15u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI80 net91 CN VSS VSS nch w=0.195u l=0.06u
MI78 net132 net120 net91 VSS nch w=0.195u l=0.06u
MI79 net132 D net91 VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.26u l=0.06u
MI142-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.2u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.305u l=0.06u
MI143-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI72-M_u3 net120 SN VDD VDD pch w=0.2u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI77 net143 D net132 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.485u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.26u l=0.06u
MI75 VDD net120 net143 VDD pch w=0.27u l=0.06u
.ends
.subckt SDFKCSND1 SI D SE CP CN SN Q QN VDD VSS
MI138-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net120 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI80 net91 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net120 net91 VSS nch w=0.2u l=0.06u
MI79 net132 D net91 VSS nch w=0.2u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.305u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net120 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI77 net143 D net132 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.485u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
MI75 VDD net120 net143 VDD pch w=0.27u l=0.06u
.ends
.subckt SDFKCSND2 SI D SE CP CN SN Q QN VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI142-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI141-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI139-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net127 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D net104 VSS nch w=0.2u l=0.06u
MI80 net104 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net127 net104 VSS nch w=0.2u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI142-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI141-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.305u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net127 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI75 VDD net127 net151 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.485u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI77 net151 D net132 VDD pch w=0.27u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
.ends
.subckt SDFKCSND4 SI D SE CP CN SN Q QN VDD VSS
MI142-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI147-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI141-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI139-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.42u l=0.06u
MI143-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.235u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI144-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI145-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net127 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.565u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D net104 VSS nch w=0.2u l=0.06u
MI80 net104 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net127 net104 VSS nch w=0.2u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI142-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI147-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI141-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.68u l=0.06u
MI143-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.315u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI144-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI145-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net127 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI75 VDD net127 net151 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI77 net151 D net132 VDD pch w=0.27u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
.ends
.subckt SDFKCSNQD0 SI D SE CP CN SN Q VDD VSS
MI131 net80 net85 VSS VSS nch w=0.175u l=0.06u
MI130 net146 net81 net80 VSS nch w=0.175u l=0.06u
MI132 net146 SE net65 VSS nch w=0.15u l=0.06u
MI118 net93 INCP net74 VSS nch w=0.21u l=0.06u
MI95 net161 INCP net104 VSS nch w=0.15u l=0.06u
MI135 net74 INCPB net074 VSS nch w=0.15u l=0.06u
MI122 net074 Q VSS VSS nch w=0.15u l=0.06u
MI83 net161 INCPB net146 VSS nch w=0.23u l=0.06u
MI133 net65 net0110 VSS VSS nch w=0.15u l=0.06u
MI96 net104 net93 VSS VSS nch w=0.15u l=0.06u
MI78 net81 net83 net135 VSS nch w=0.195u l=0.06u
MI79 net81 D net135 VSS nch w=0.195u l=0.06u
MI80 net135 CN VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net85 SE VSS VSS nch w=0.195u l=0.06u
MI141-M_u2 net0110 SI VSS VSS nch w=0.15u l=0.06u
MI121-M_u2 Q net74 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 net161 VSS VSS nch w=0.34u l=0.06u
MI140-M_u2 net83 SN VSS VSS nch w=0.15u l=0.06u
MI139-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI45-M_u3 net85 SE VDD VDD pch w=0.26u l=0.06u
MI141-M_u3 net0110 SI VDD VDD pch w=0.15u l=0.06u
MI121-M_u3 Q net74 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 net161 VDD VDD pch w=0.34u l=0.06u
MI140-M_u3 net83 SN VDD VDD pch w=0.2u l=0.06u
MI126 net117 net81 net140 VDD pch w=0.255u l=0.06u
MI82 net161 INCP net117 VDD pch w=0.3u l=0.06u
MI128 net117 net85 net129 VDD pch w=0.2u l=0.06u
MI127 net140 SE VDD VDD pch w=0.255u l=0.06u
MI129 net129 net0110 VDD VDD pch w=0.2u l=0.06u
MI136 net0126 Q VDD VDD pch w=0.15u l=0.06u
MI123 net74 INCP net0126 VDD pch w=0.15u l=0.06u
MI125 net93 INCPB net74 VDD pch w=0.43u l=0.06u
MI74 VDD CN net81 VDD pch w=0.375u l=0.06u
MI94 net170 net93 VDD VDD pch w=0.15u l=0.06u
MI93 net161 INCPB net170 VDD pch w=0.15u l=0.06u
MI75 VDD net83 net173 VDD pch w=0.375u l=0.06u
MI77 net173 D net81 VDD pch w=0.375u l=0.06u
.ends
.subckt SDFKCSNQD1 SI D SE CP CN SN Q VDD VSS
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI139-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI140-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net120 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI80 net91 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net120 net91 VSS nch w=0.2u l=0.06u
MI79 net132 D net91 VSS nch w=0.2u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI139-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI140-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.305u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net120 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI77 net143 D net132 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.485u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
MI75 VDD net120 net143 VDD pch w=0.27u l=0.06u
.ends
.subckt SDFKCSNQD2 SI D SE CP CN SN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI142-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI141-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI143-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net127 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.235u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D net104 VSS nch w=0.2u l=0.06u
MI80 net104 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net127 net104 VSS nch w=0.2u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI142-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI141-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.305u l=0.06u
MI143-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net127 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI75 VDD net127 net151 VDD pch w=0.27u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.485u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI77 net151 D net132 VDD pch w=0.27u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
.ends
.subckt SDFKCSNQD4 SI D SE CP CN SN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.365u l=0.06u
MI49-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.185u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI42_1-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net239 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.565u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI80 net216 CN VSS VSS nch w=0.2u l=0.06u
MI78 net132 net239 net216 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI79 net132 D net216 VSS nch w=0.2u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.515u l=0.06u
MI49-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI42_1-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net239 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.28u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI77 net271 D net132 VDD pch w=0.27u l=0.06u
MI74 VDD CN net132 VDD pch w=0.235u l=0.06u
MI75 VDD net239 net271 VDD pch w=0.27u l=0.06u
.ends
.subckt SDFKSND0 SI D SE CP SN Q QN VDD VSS
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.15u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI141-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI142-M_u2 QN net69 VSS VSS nch w=0.195u l=0.06u
MI72-M_u2 net116 SN VSS VSS nch w=0.15u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.24u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI78 net132 net116 VSS VSS nch w=0.195u l=0.06u
MI79 net132 D VSS VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI49-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.2u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.33u l=0.06u
MI141-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI142-M_u3 QN net69 VDD VDD pch w=0.26u l=0.06u
MI72-M_u3 net116 SN VDD VDD pch w=0.2u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.51u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net116 net139 VDD pch w=0.26u l=0.06u
MI77 net139 D net132 VDD pch w=0.26u l=0.06u
.ends
.subckt SDFKSND1 SI D SE CP SN Q QN VDD VSS
MI138-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI142-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI140-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net116 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.24u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI78 net132 net116 VSS VSS nch w=0.195u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI142-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI140-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.33u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net116 SN VDD VDD pch w=0.28u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.51u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net116 net139 VDD pch w=0.28u l=0.06u
MI77 net139 D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKSND2 SI D SE CP SN Q QN VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI142-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net123 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.24u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI78 net132 net123 VSS VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.33u l=0.06u
MI142-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net123 SN VDD VDD pch w=0.28u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.51u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net123 net145 VDD pch w=0.28u l=0.06u
MI77 net145 D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKSND4 SI D SE CP SN Q QN VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI136-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI142-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.42u l=0.06u
MI115-M_u2 net69 net105 VSS VSS nch w=0.245u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI143-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI141-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI144-M_u2 QN net69 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net123 SN VSS VSS nch w=0.195u l=0.06u
MI145-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.535u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI78 net132 net123 VSS VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI136-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI142-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.68u l=0.06u
MI115-M_u3 net69 net105 VDD VDD pch w=0.33u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI143-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI141-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI144-M_u3 QN net69 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net123 SN VDD VDD pch w=0.28u l=0.06u
MI145-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net123 net145 VDD pch w=0.28u l=0.06u
MI77 net145 D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKSNQD0 SI D SE CP SN Q VDD VSS
MI64 net77 net85 VSS VSS nch w=0.195u l=0.06u
MI65 net146 net81 net77 VSS nch w=0.195u l=0.06u
MI62 net146 SE net102 VSS nch w=0.15u l=0.06u
MI89 net158 INCP net87 VSS nch w=0.15u l=0.06u
MI90 net87 net93 VSS VSS nch w=0.15u l=0.06u
MI106 net93 INCP net69 VSS nch w=0.21u l=0.06u
MI122 net068 Q VSS VSS nch w=0.15u l=0.06u
MI135 net69 INCPB net068 VSS nch w=0.15u l=0.06u
MI83 net158 INCPB net146 VSS nch w=0.23u l=0.06u
MI63 net102 net0102 VSS VSS nch w=0.15u l=0.06u
MI78 net81 net83 VSS VSS nch w=0.195u l=0.06u
MI79 net81 D VSS VSS nch w=0.195u l=0.06u
MI115-M_u2 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net85 SE VSS VSS nch w=0.15u l=0.06u
MI116-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net158 VSS VSS nch w=0.34u l=0.06u
MI109-M_u2 Q net69 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net83 SN VSS VSS nch w=0.15u l=0.06u
MI115-M_u3 net0102 SI VDD VDD pch w=0.2u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI45-M_u3 net85 SE VDD VDD pch w=0.2u l=0.06u
MI116-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net158 VDD VDD pch w=0.34u l=0.06u
MI109-M_u3 Q net69 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net83 SN VDD VDD pch w=0.2u l=0.06u
MI123 net69 INCP net0115 VDD pch w=0.15u l=0.06u
MI50 net130 SE VDD VDD pch w=0.255u l=0.06u
MI82 net158 INCP net117 VDD pch w=0.3u l=0.06u
MI53 net117 net85 net145 VDD pch w=0.15u l=0.06u
MI88 net150 net93 VDD VDD pch w=0.15u l=0.06u
MI51 net117 net81 net130 VDD pch w=0.255u l=0.06u
MI52 net145 net0102 VDD VDD pch w=0.15u l=0.06u
MI87 net158 INCPB net150 VDD pch w=0.15u l=0.06u
MI136 net0115 Q VDD VDD pch w=0.15u l=0.06u
MI113 net93 INCPB net69 VDD pch w=0.43u l=0.06u
MI75 VDD net83 net166 VDD pch w=0.26u l=0.06u
MI77 net166 D net81 VDD pch w=0.26u l=0.06u
.ends
.subckt SDFKSNQD1 SI D SE CP SN Q VDD VSS
MI142-M_u2 net69 net105 VSS VSS nch w=0.15u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI141-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI140-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net116 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.24u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI78 net132 net116 VSS VSS nch w=0.195u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI142-M_u3 net69 net105 VDD VDD pch w=0.15u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI141-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI140-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.33u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net116 SN VDD VDD pch w=0.28u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.51u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net116 net139 VDD pch w=0.28u l=0.06u
MI77 net139 D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKSNQD2 SI D SE CP SN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI142-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI141-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI144-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI72-M_u2 net123 SN VSS VSS nch w=0.195u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.24u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.26u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI78 net132 net123 VSS VSS nch w=0.195u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI142-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI141-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net93 net155 VDD VDD pch w=0.33u l=0.06u
MI144-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI72-M_u3 net123 SN VDD VDD pch w=0.26u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.51u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI75 VDD net123 net145 VDD pch w=0.28u l=0.06u
MI77 net145 D net132 VDD pch w=0.52u l=0.06u
.ends
.subckt SDFKSNQD4 SI D SE CP SN Q VDD VSS
MI138-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI130-M_u2 net109 net90 VSS VSS nch w=0.39u l=0.06u
MI145-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 net107 SE VSS VSS nch w=0.195u l=0.06u
MI72-M_u2 net235 SN VSS VSS nch w=0.195u l=0.06u
MI139-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI140-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI42_0-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI42_1-M_u2 net93 net155 VSS VSS nch w=0.21u l=0.06u
MI147-M_u2 net69 net105 VSS VSS nch w=0.195u l=0.06u
MI116-M_u2 Q net105 VSS VSS nch w=0.39u l=0.06u
MI112 net93 INCP net105 VSS nch w=0.535u l=0.06u
MI135 net87 SI VSS VSS nch w=0.15u l=0.06u
MI128 net132 net107 net90 VSS nch w=0.2u l=0.06u
MI29 net105 INCPB net79 VSS nch w=0.15u l=0.06u
MI26 net79 net69 VSS VSS nch w=0.15u l=0.06u
MI126 net109 INCPB net155 VSS nch w=0.27u l=0.06u
MI101 net155 INCP net95 VSS nch w=0.15u l=0.06u
MI102 net95 net93 VSS VSS nch w=0.15u l=0.06u
MI78 net132 net235 VSS VSS nch w=0.195u l=0.06u
MI79 net132 D VSS VSS nch w=0.39u l=0.06u
MI134 net90 SE net87 VSS nch w=0.15u l=0.06u
MI138-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI130-M_u3 net109 net90 VDD VDD pch w=0.51u l=0.06u
MI145-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 net107 SE VDD VDD pch w=0.26u l=0.06u
MI72-M_u3 net235 SN VDD VDD pch w=0.26u l=0.06u
MI139-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI140-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI42_0-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI42_1-M_u3 net93 net155 VDD VDD pch w=0.34u l=0.06u
MI147-M_u3 net69 net105 VDD VDD pch w=0.26u l=0.06u
MI116-M_u3 Q net105 VDD VDD pch w=0.52u l=0.06u
MI28 net105 INCP net168 VDD pch w=0.15u l=0.06u
MI129 net132 SE net90 VDD pch w=0.38u l=0.06u
MI24 net168 net69 VDD VDD pch w=0.15u l=0.06u
MI133 net138 net107 net90 VDD pch w=0.2u l=0.06u
MI119 net93 INCPB net105 VDD pch w=0.97u l=0.06u
MI127 net109 INCP net155 VDD pch w=0.34u l=0.06u
MI99 net155 INCPB net153 VDD pch w=0.15u l=0.06u
MI100 net153 net93 VDD VDD pch w=0.15u l=0.06u
MI131 VDD SI net138 VDD pch w=0.2u l=0.06u
MI77 net265 D net132 VDD pch w=0.52u l=0.06u
MI75 VDD net235 net265 VDD pch w=0.28u l=0.06u
.ends
.subckt SDFNCND0 SI D SE CPN CDN Q QN VDD VSS
MI162 net177 D net072 VSS nch w=0.26u l=0.06u
MI150 net62 net101 d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCPB d2 VSS nch w=0.2u l=0.06u
MI49 net79 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net82 d1 net79 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net82 VSS nch w=0.15u l=0.06u
MI77 d0 net101 net177 VSS nch w=0.16u l=0.06u
MI78 net89 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net89 VSS nch w=0.15u l=0.06u
MI81 net072 net120 VSS VSS nch w=0.26u l=0.06u
MI167-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI168-M_u2 QN net62 VSS VSS nch w=0.195u l=0.06u
MI172-M_u2 net62 d3 VSS VSS nch w=0.195u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.15u l=0.06u
MI165-M_u2 INCPB CPN VSS VSS nch w=0.15u l=0.06u
MI171-M_u2 net101 INCPB VSS VSS nch w=0.195u l=0.06u
MI173-M_u4 XI173-net6 CDN VSS VSS nch w=0.35u l=0.06u
MI173-M_u3 d3 d2 XI173-net6 VSS nch w=0.35u l=0.06u
MI167-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI168-M_u3 QN net62 VDD VDD pch w=0.26u l=0.06u
MI172-M_u3 net62 d3 VDD VDD pch w=0.26u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.2u l=0.06u
MI165-M_u3 INCPB CPN VDD VDD pch w=0.2u l=0.06u
MI171-M_u3 net101 INCPB VDD VDD pch w=0.26u l=0.06u
MI164 net117 D net69 VDD pch w=0.33u l=0.06u
MI155 net62 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net101 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI163 net117 net120 net142 VDD pch w=0.15u l=0.06u
MI73 net69 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCPB net117 VDD pch w=0.49u l=0.06u
MI75 net142 SI VDD VDD pch w=0.15u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 net101 d2 VDD pch w=0.29u l=0.06u
MI173-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI173-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
.ends
.subckt SDFNCND1 SI D SE CPN CDN Q QN VDD VSS
MI162 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI150 net62 net101 d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCPB d2 VSS nch w=0.2u l=0.06u
MI49 net79 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net82 d1 net79 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net82 VSS nch w=0.15u l=0.06u
MI77 d0 net101 net177 VSS nch w=0.16u l=0.06u
MI78 net89 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net89 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.4u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI179-M_u2 net62 d3 VSS VSS nch w=0.195u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.23u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI165-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI178-M_u2 net101 INCPB VSS VSS nch w=0.195u l=0.06u
MI180-M_u4 XI180-net6 CDN VSS VSS nch w=0.35u l=0.06u
MI180-M_u3 d3 d2 XI180-net6 VSS nch w=0.35u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI179-M_u3 net62 d3 VDD VDD pch w=0.26u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI165-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI178-M_u3 net101 INCPB VDD VDD pch w=0.26u l=0.06u
MI164 net117 SE net69 VDD pch w=0.44u l=0.06u
MI155 net62 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net101 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI163 net117 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.51u l=0.06u
MI74 d0 INCPB net117 VDD pch w=0.49u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 net101 d2 VDD pch w=0.29u l=0.06u
MI180-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI180-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
.ends
.subckt SDFNCND2 SI D SE CPN CDN Q QN VDD VSS
MI162 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI150 net62 net101 d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net79 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net82 d1 net79 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net82 VSS nch w=0.15u l=0.06u
MI77 d0 net101 net177 VSS nch w=0.17u l=0.06u
MI78 net89 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net89 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.4u l=0.06u
MI165-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI159-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI160-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI153-M_u2 net62 d3 VSS VSS nch w=0.23u l=0.06u
MI168-M_u2 net101 INCPB VSS VSS nch w=0.195u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158-M_u3 d3 d2 XI158-net6 VSS nch w=0.23u l=0.06u
MI167-M_u4 XI167-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI167-M_u3 d3 d2 XI167-net6 VSS nch w=0.23u l=0.06u
MI165-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI159-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI160-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI153-M_u3 net62 d3 VDD VDD pch w=0.33u l=0.06u
MI168-M_u3 net101 INCPB VDD VDD pch w=0.26u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.34u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI164 net117 SE net69 VDD pch w=0.44u l=0.06u
MI155 net62 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net101 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI163 net117 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.51u l=0.06u
MI74 d0 INCPB net117 VDD pch w=0.49u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 net101 d2 VDD pch w=0.4u l=0.06u
MI158-M_u2 d3 CDN VDD VDD pch w=0.33u l=0.06u
MI158-M_u1 d3 d2 VDD VDD pch w=0.33u l=0.06u
MI167-M_u2 d3 CDN VDD VDD pch w=0.33u l=0.06u
MI167-M_u1 d3 d2 VDD VDD pch w=0.33u l=0.06u
.ends
.subckt SDFNCND4 SI D SE CPN CDN Q QN VDD VSS
MI162 net177 net120 net69 VSS nch w=0.35u l=0.06u
MI150 net62 net101 d2 VSS nch w=0.15u l=0.06u
MI149 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net79 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net82 d1 net79 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net82 VSS nch w=0.15u l=0.06u
MI77 d0 net101 net177 VSS nch w=0.17u l=0.06u
MI78 net89 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net89 VSS nch w=0.15u l=0.06u
MI81 net69 D VSS VSS nch w=0.39u l=0.06u
MI165-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI159-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI160-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI151-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI153-M_u2 net62 d3 VSS VSS nch w=0.62u l=0.06u
MI166-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI174-M_u2 net101 INCPB VSS VSS nch w=0.39u l=0.06u
MI167-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI168-M_u2 QN net62 VSS VSS nch w=0.39u l=0.06u
MI85-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI173-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI158-M_u4 XI158-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI158-M_u3 d3 d2 XI158-net6 VSS nch w=0.23u l=0.06u
MI170-M_u4 XI170-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI170-M_u3 d3 d2 XI170-net6 VSS nch w=0.23u l=0.06u
MI165-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI159-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI160-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI151-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI153-M_u3 net62 d3 VDD VDD pch w=0.85u l=0.06u
MI166-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI174-M_u3 net101 INCPB VDD VDD pch w=0.52u l=0.06u
MI167-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI168-M_u3 QN net62 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 d1 d0 VDD VDD pch w=0.34u l=0.06u
MI173-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI164 net117 SE net69 VDD pch w=0.44u l=0.06u
MI155 net62 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net101 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI163 net117 net120 net142 VDD pch w=0.2u l=0.06u
MI73 net69 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net117 VDD pch w=0.47u l=0.06u
MI75 net142 SI VDD VDD pch w=0.2u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI154 d1 net101 d2 VDD pch w=0.4u l=0.06u
MI158-M_u2 d3 CDN VDD VDD pch w=0.33u l=0.06u
MI158-M_u1 d3 d2 VDD VDD pch w=0.33u l=0.06u
MI170-M_u2 d3 CDN VDD VDD pch w=0.33u l=0.06u
MI170-M_u1 d3 d2 VDD VDD pch w=0.33u l=0.06u
.ends
.subckt SDFNCSND0 SI D SE CPN CDN SDN Q QN VDD VSS
MI91 d4 net105 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net86 VSS nch w=0.15u l=0.06u
MI77 d0 net105 net177 VSS nch w=0.17u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI79 net96 net120 VSS VSS nch w=0.26u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net177 D net96 VSS nch w=0.26u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.15u l=0.06u
MI31-M_u2 INCPB CPN VSS VSS nch w=0.15u l=0.06u
MI100-M_u2 net105 INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.15u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.2u l=0.06u
MI31-M_u3 INCPB CPN VDD VDD pch w=0.2u l=0.06u
MI100-M_u3 net105 INCPB VDD VDD pch w=0.26u l=0.06u
MI45 d0 net105 net166 VDD pch w=0.15u l=0.06u
MI43 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.15u l=0.06u
MI72 net149 SE VDD VDD pch w=0.33u l=0.06u
MI73 net104 D net149 VDD pch w=0.33u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.49u l=0.06u
MI75 net148 SI VDD VDD pch w=0.15u l=0.06u
MI98 d1 net105 d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.2u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFNCSND1 SI D SE CPN CDN SDN Q QN VDD VSS
MI91 d4 net105 d2 VSS nch w=0.15u l=0.06u
MI102 net177 net120 net84 VSS nch w=0.35u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net86 VSS nch w=0.15u l=0.06u
MI77 d0 net105 net177 VSS nch w=0.17u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net84 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI108-M_u2 net105 INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI103-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI108-M_u3 net105 INCPB VDD VDD pch w=0.26u l=0.06u
MI101 net104 SE net84 VDD pch w=0.44u l=0.06u
MI105 d0 net105 net166 VDD pch w=0.15u l=0.06u
MI104 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net84 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.49u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 net105 d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFNCSND2 SI D SE CPN CDN SDN Q QN VDD VSS
MI91 d4 net105 d2 VSS nch w=0.15u l=0.06u
MI102 net177 net120 net84 VSS nch w=0.35u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net86 VSS nch w=0.15u l=0.06u
MI77 d0 net105 net177 VSS nch w=0.17u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net84 D VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI100-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI104-M_u2 net105 INCPB VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI100-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI104-M_u3 net105 INCPB VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI101 net104 SE net84 VDD pch w=0.44u l=0.06u
MI107 d0 net105 net166 VDD pch w=0.15u l=0.06u
MI106 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net84 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.49u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 net105 d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.38u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.38u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFNCSND4 SI D SE CPN CDN SDN Q QN VDD VSS
MI91 d4 net105 d2 VSS nch w=0.15u l=0.06u
MI102 net177 net120 net84 VSS nch w=0.35u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI49 net83 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net86 d1 net83 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net86 VSS nch w=0.15u l=0.06u
MI77 d0 net105 net177 VSS nch w=0.17u l=0.06u
MI78 net93 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net93 VSS nch w=0.15u l=0.06u
MI81 net84 D VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI100-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI104-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI105-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI114-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI115-M_u2 net105 INCPB VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.35u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.35u l=0.06u
MI94-M_u4 XI94-net6 d2 VSS VSS nch w=0.17u l=0.06u
MI94-M_u3 d3 CDN XI94-net6 VSS nch w=0.17u l=0.06u
MI107-M_u4 XI107-net6 d2 VSS VSS nch w=0.35u l=0.06u
MI107-M_u3 d3 CDN XI107-net6 VSS nch w=0.35u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.21u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI95-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI100-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI104-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI105-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI114-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI115-M_u3 net105 INCPB VDD VDD pch w=0.52u l=0.06u
MI101 net104 SE net84 VDD pch w=0.44u l=0.06u
MI109 d0 net105 net166 VDD pch w=0.15u l=0.06u
MI108 net166 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net148 VDD pch w=0.2u l=0.06u
MI73 net84 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.45u l=0.06u
MI75 net148 SI VDD VDD pch w=0.2u l=0.06u
MI98 d1 net105 d2 VDD pch w=0.32u l=0.06u
MI44 net166 CDN VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.38u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.38u l=0.06u
MI94-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI94-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI107-M_u2 d3 d2 VDD VDD pch w=0.32u l=0.06u
MI107-M_u1 d3 CDN VDD VDD pch w=0.32u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.4u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SDFND0 SI D SE CPN Q QN VDD VSS
MI25 net65 INCPB d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCPB net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 net89 d2 VSS nch w=0.15u l=0.06u
MU65 net28 net89 net37 VSS nch w=0.21u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU64 net81 net57 VSS VSS nch w=0.26u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net37 D net81 VSS nch w=0.26u l=0.06u
MI39-M_u2 net55 d3 VSS VSS nch w=0.15u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.195u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.15u l=0.06u
MU84-M_u2 INCPB CPN VSS VSS nch w=0.15u l=0.06u
MI38-M_u2 net89 INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI39-M_u3 net55 d3 VDD VDD pch w=0.2u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.26u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.2u l=0.06u
MU84-M_u3 INCPB CPN VDD VDD pch w=0.2u l=0.06u
MI38-M_u3 net89 INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCPB d2 VDD pch w=0.15u l=0.06u
MI36 net65 net89 d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.15u l=0.06u
MU60 net128 SE VDD VDD pch w=0.33u l=0.06u
MU61 net13 D net128 VDD pch w=0.33u l=0.06u
MU62 net28 INCPB net13 VDD pch w=0.28u l=0.06u
MU70 net132 SI VDD VDD pch w=0.15u l=0.06u
MI10 net28 net89 net137 VDD pch w=0.15u l=0.06u
.ends
.subckt SDFND1 SI D SE CPN Q QN VDD VSS
MI39 net37 net57 net110 VSS nch w=0.35u l=0.06u
MI25 net65 INCPB d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCPB net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 net89 d2 VSS nch w=0.15u l=0.06u
MU65 net28 net89 net37 VSS nch w=0.21u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net110 D VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.195u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MI41-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI43-M_u2 net89 INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=0.26u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MI41-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI43-M_u3 net89 INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCPB d2 VDD pch w=0.15u l=0.06u
MI40 net13 SE net110 VDD pch w=0.44u l=0.06u
MI36 net65 net89 d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net110 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCPB net13 VDD pch w=0.28u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 net89 net137 VDD pch w=0.15u l=0.06u
.ends
.subckt SDFND2 SI D SE CPN Q QN VDD VSS
MI39 net37 net57 net110 VSS nch w=0.35u l=0.06u
MI25 net65 INCPB d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCPB net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 net89 d2 VSS nch w=0.15u l=0.06u
MU65 net28 net89 net37 VSS nch w=0.21u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net110 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI41-M_u2 net89 INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI41-M_u3 net89 INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCPB d2 VDD pch w=0.15u l=0.06u
MI40 net13 SE net110 VDD pch w=0.44u l=0.06u
MI36 net65 net89 d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net110 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCPB net13 VDD pch w=0.28u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 net89 net137 VDD pch w=0.15u l=0.06u
.ends
.subckt SDFND4 SI D SE CPN Q QN VDD VSS
MI39 net37 net57 net110 VSS nch w=0.35u l=0.06u
MI25 net65 INCPB d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCPB net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI26 net55 net89 d2 VSS nch w=0.15u l=0.06u
MU65 net28 net89 net37 VSS nch w=0.21u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net110 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net55 d3 VSS VSS nch w=0.78u l=0.06u
MI30_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI30_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI41-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI43-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MU85-M_u2 net89 INCPB VSS VSS nch w=0.39u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net55 d3 VDD VDD pch w=1.04u l=0.06u
MI30_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI30_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI43-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI44-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MU85-M_u3 net89 INCPB VDD VDD pch w=0.52u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI35 net55 INCPB d2 VDD pch w=0.15u l=0.06u
MI40 net13 SE net110 VDD pch w=0.44u l=0.06u
MI36 net65 net89 d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net110 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCPB net13 VDD pch w=0.28u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 net89 net137 VDD pch w=0.15u l=0.06u
.ends
.subckt SDFNSND0 SI D SE CPN SDN Q QN VDD VSS
MI91 d4 net95 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.39u l=0.06u
MI101 net177 D net76 VSS nch w=0.26u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net72 VSS nch w=0.15u l=0.06u
MI77 d0 net95 net177 VSS nch w=0.17u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net76 net095 VSS VSS nch w=0.26u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net095 SE VSS VSS nch w=0.15u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CPN VSS VSS nch w=0.15u l=0.06u
MI105-M_u2 net95 INCPB VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 QN d4 VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.15u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net095 SE VDD VDD pch w=0.2u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CPN VDD VDD pch w=0.2u l=0.06u
MI105-M_u3 net95 INCPB VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 QN d4 VDD VDD pch w=0.26u l=0.06u
MI102 net104 D net0117 VDD pch w=0.33u l=0.06u
MI45 d0 net95 net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net095 net131 VDD pch w=0.15u l=0.06u
MI73 net0117 SE VDD VDD pch w=0.33u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.47u l=0.06u
MI75 net131 SI VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI98 d1 net95 d2 VDD pch w=0.315u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFNSND1 SI D SE CPN SDN Q QN VDD VSS
MI91 d4 net95 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.39u l=0.06u
MI101 net177 net120 net76 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net72 VSS nch w=0.15u l=0.06u
MI77 d0 net95 net177 VSS nch w=0.17u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net76 D VSS VSS nch w=0.39u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI104-M_u2 net95 INCPB VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI104-M_u3 net95 INCPB VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI102 net104 SE net76 VDD pch w=0.44u l=0.06u
MI45 d0 net95 net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net76 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.49u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI98 d1 net95 d2 VDD pch w=0.315u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFNSND2 SI D SE CPN SDN Q QN VDD VSS
MI91 d4 net95 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.39u l=0.06u
MI101 net177 net120 net76 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net72 VSS nch w=0.15u l=0.06u
MI77 d0 net95 net177 VSS nch w=0.17u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net76 D VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 net95 INCPB VSS VSS nch w=0.195u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI100-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI104-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI95-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.39u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.39u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI103-M_u3 net95 INCPB VDD VDD pch w=0.26u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI100-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI104-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI95-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI102 net104 SE net76 VDD pch w=0.44u l=0.06u
MI45 d0 net95 net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net76 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.47u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI98 d1 net95 d2 VDD pch w=0.315u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFNSND4 SI D SE CPN SDN Q QN VDD VSS
MI91 d4 net95 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCPB d2 VSS nch w=0.39u l=0.06u
MI101 net177 net120 net76 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net72 VSS nch w=0.15u l=0.06u
MI77 d0 net95 net177 VSS nch w=0.17u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net76 D VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI110-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI109-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI111-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI114-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI107-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI112-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI96_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI115-M_u2 net95 INCPB VSS VSS nch w=0.39u l=0.06u
MI113-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.39u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.39u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI108-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI110-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI109-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI111-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI114-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI107-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI112-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI96_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI115-M_u3 net95 INCPB VDD VDD pch w=0.52u l=0.06u
MI113-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI102 net104 SE net76 VDD pch w=0.44u l=0.06u
MI45 d0 net95 net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net76 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCPB net104 VDD pch w=0.47u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI97 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI98 d1 net95 d2 VDD pch w=0.315u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFQD0 SI D SE CP Q VDD VSS
MI39 net117 d3 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net117 VSS nch w=0.15u l=0.06u
MI25 net110 INCP d2 VSS nch w=0.15u l=0.06u
MI13 net69 INCP net109 VSS nch w=0.15u l=0.06u
MI14 net109 net110 VSS VSS nch w=0.15u l=0.06u
MU65 net69 INCPB net97 VSS nch w=0.15u l=0.06u
MU67 net103 SI VSS VSS nch w=0.15u l=0.06u
MI51 net97 net78 VSS VSS nch w=0.15u l=0.06u
MI42 net78 D net94 VSS nch w=0.23u l=0.06u
MU68 net78 SE net103 VSS nch w=0.15u l=0.06u
MU63 net94 net131 VSS VSS nch w=0.23u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.15u l=0.06u
MI49-M_u2 Q d2 VSS VSS nch w=0.15u l=0.06u
MU71-M_u2 net131 SE VSS VSS nch w=0.19u l=0.06u
MI43-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI46-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net110 net69 VSS VSS nch w=0.21u l=0.06u
MI24 net87 d3 VDD VDD pch w=0.15u l=0.06u
MI11 net65 net110 VDD VDD pch w=0.15u l=0.06u
MI50 net057 net78 VDD VDD pch w=0.25u l=0.06u
MI36 net110 INCPB d2 VDD pch w=0.35u l=0.06u
MU69 net78 net131 net80 VDD pch w=0.15u l=0.06u
MI41 net78 D net77 VDD pch w=0.3u l=0.06u
MU61 net77 SE VDD VDD pch w=0.38u l=0.06u
MU62 net69 INCP net057 VDD pch w=0.25u l=0.06u
MU70 net80 SI VDD VDD pch w=0.15u l=0.06u
MI10 net69 INCPB net65 VDD pch w=0.15u l=0.06u
MI38 d2 INCP net87 VDD pch w=0.15u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.15u l=0.06u
MI49-M_u3 Q d2 VDD VDD pch w=0.24u l=0.06u
MU71-M_u3 net131 SE VDD VDD pch w=0.26u l=0.06u
MI43-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI46-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net110 net69 VDD VDD pch w=0.335u l=0.06u
.ends
.subckt SDFQD1 SI D SE CP Q VDD VSS
MI30-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MI43-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI46-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI39 net60 d3 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net60 VSS nch w=0.15u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.18u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MI42 net37 net57 net13 VSS nch w=0.35u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net13 D VSS VSS nch w=0.39u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MI43-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI46-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI38 d2 INCP net62 VDD pch w=0.15u l=0.06u
MI24 net62 d3 VDD VDD pch w=0.15u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net120 net57 net132 VDD pch w=0.2u l=0.06u
MI41 net120 SE net13 VDD pch w=0.44u l=0.06u
MU61 net13 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net120 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
.ends
.subckt SDFQD2 SI D SE CP Q VDD VSS
MI39 net37 net57 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI45 net061 d3 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net061 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.15u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI46-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI33-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI46-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI33-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI24 net0110 d3 VDD VDD pch w=0.15u l=0.06u
MI38 d2 INCP net0110 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFQD4 SI D SE CP Q VDD VSS
MI39 net37 net57 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net0155 VSS nch w=0.15u l=0.06u
MI49 net0155 net55 VSS VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.17u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 Q net55 VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI51-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 Q net55 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 net55 d2 VSS VSS nch w=0.78u l=0.06u
MI45-M_u2 Q net55 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 Q net55 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI37-M_u3 Q net55 VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI51-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI44-M_u3 Q net55 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 net55 d2 VDD VDD pch w=1.04u l=0.06u
MI45-M_u3 Q net55 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 Q net55 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI38 d2 INCP net0203 VDD pch w=0.15u l=0.06u
MI24 net0203 net55 VDD VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.3u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFQND0 SI D SE CP QN VDD VSS
MI30-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.15u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI44-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI39 net37 D net64 VSS nch w=0.26u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI41 net054 QN VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net054 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.16u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 net57 VSS VSS nch w=0.26u l=0.06u
MI30-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.2u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI44-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI24 net064 QN VDD VDD pch w=0.15u l=0.06u
MI38 d2 INCP net064 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.15u l=0.06u
MU61 net0111 SE VDD VDD pch w=0.33u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.33u l=0.06u
MU70 net132 SI VDD VDD pch w=0.15u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 D net0111 VDD pch w=0.33u l=0.06u
.ends
.subckt SDFQND1 SI D SE CP QN VDD VSS
MI39 net37 net57 net64 VSS nch w=0.35u l=0.06u
MI25 net65 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net28 INCP net66 VSS nch w=0.15u l=0.06u
MI14 net66 net65 VSS VSS nch w=0.15u l=0.06u
MI45 net054 net55 VSS VSS nch w=0.15u l=0.06u
MI44 d2 INCPB net054 VSS nch w=0.15u l=0.06u
MU65 net28 INCPB net37 VSS nch w=0.16u l=0.06u
MU67 net83 SI VSS VSS nch w=0.15u l=0.06u
MU68 net37 SE net83 VSS nch w=0.15u l=0.06u
MU63 net64 D VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 net55 d2 VSS VSS nch w=0.15u l=0.06u
MI49-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net57 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net65 net28 VSS VSS nch w=0.35u l=0.06u
MI30-M_u3 net55 d2 VDD VDD pch w=0.15u l=0.06u
MI49-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net57 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net65 net28 VDD VDD pch w=0.38u l=0.06u
MI11 net137 net65 VDD VDD pch w=0.15u l=0.06u
MI46 net098 net55 VDD VDD pch w=0.15u l=0.06u
MI47 d2 INCP net098 VDD pch w=0.15u l=0.06u
MI36 net65 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net13 net57 net132 VDD pch w=0.2u l=0.06u
MU61 net64 D VDD VDD pch w=0.52u l=0.06u
MU62 net28 INCP net13 VDD pch w=0.33u l=0.06u
MU70 net132 SI VDD VDD pch w=0.2u l=0.06u
MI10 net28 INCPB net137 VDD pch w=0.15u l=0.06u
MI40 net13 SE net64 VDD pch w=0.44u l=0.06u
.ends
.subckt SDFQND2 SI D SE CP QN VDD VSS
MI11 net83 net120 VDD VDD pch w=0.15u l=0.06u
MI46 net79 net98 VDD VDD pch w=0.15u l=0.06u
MI47 d2 INCP net79 VDD pch w=0.15u l=0.06u
MI40 net71 SE net101 VDD pch w=0.44u l=0.06u
MI36 net120 INCPB d2 VDD pch w=0.44u l=0.06u
MU69 net71 net94 net73 VDD pch w=0.2u l=0.06u
MU61 net101 D VDD VDD pch w=0.52u l=0.06u
MU62 net65 INCP net71 VDD pch w=0.33u l=0.06u
MU70 net73 SI VDD VDD pch w=0.2u l=0.06u
MI10 net65 INCPB net83 VDD pch w=0.15u l=0.06u
MI30-M_u3 net98 d2 VDD VDD pch w=0.15u l=0.06u
MI49-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net94 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI50-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU72-M_u3 net120 net65 VDD VDD pch w=0.38u l=0.06u
MI30-M_u2 net98 d2 VSS VSS nch w=0.15u l=0.06u
MI49-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net94 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI50-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU72-M_u2 net120 net65 VSS VSS nch w=0.35u l=0.06u
MU68 net104 SE net103 VSS nch w=0.15u l=0.06u
MI39 net104 net94 net101 VSS nch w=0.35u l=0.06u
MU63 net101 D VSS VSS nch w=0.39u l=0.06u
MI25 net120 INCP d2 VSS nch w=0.22u l=0.06u
MI13 net65 INCP net119 VSS nch w=0.15u l=0.06u
MI14 net119 net120 VSS VSS nch w=0.15u l=0.06u
MI45 net112 net98 VSS VSS nch w=0.15u l=0.06u
MI44 d2 INCPB net112 VSS nch w=0.15u l=0.06u
MU65 net65 INCPB net104 VSS nch w=0.16u l=0.06u
MU67 net103 SI VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SDFQND4 SI D SE CP QN VDD VSS
MI13 net66 INCP net77 VSS nch w=0.15u l=0.06u
MI14 net77 net76 VSS VSS nch w=0.15u l=0.06u
MI25 net76 INCP d2 VSS nch w=0.22u l=0.06u
MI44 d2 INCPB net72 VSS nch w=0.15u l=0.06u
MU67 net63 SI VSS VSS nch w=0.15u l=0.06u
MI45 net72 net110 VSS VSS nch w=0.15u l=0.06u
MU65 net66 INCPB net90 VSS nch w=0.16u l=0.06u
MU63 net84 D VSS VSS nch w=0.39u l=0.06u
MU68 net90 SE net63 VSS nch w=0.15u l=0.06u
MI39 net90 net106 net84 VSS nch w=0.35u l=0.06u
MI54-M_u2 net76 net66 VSS VSS nch w=0.35u l=0.06u
MI51-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MI52-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 net110 d2 VSS VSS nch w=0.15u l=0.06u
MI49-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MU71-M_u2 net106 SE VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 QN d2 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI54-M_u3 net76 net66 VDD VDD pch w=0.38u l=0.06u
MI51-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MI52-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 net110 d2 VDD VDD pch w=0.15u l=0.06u
MI49-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MU71-M_u3 net106 SE VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 QN d2 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI11 net139 net76 VDD VDD pch w=0.15u l=0.06u
MI46 net136 net110 VDD VDD pch w=0.15u l=0.06u
MI47 d2 INCP net136 VDD pch w=0.15u l=0.06u
MI40 net124 SE net84 VDD pch w=0.44u l=0.06u
MI36 net76 INCPB d2 VDD pch w=0.44u l=0.06u
MU70 net126 SI VDD VDD pch w=0.2u l=0.06u
MI10 net66 INCPB net139 VDD pch w=0.15u l=0.06u
MU69 net124 net106 net126 VDD pch w=0.2u l=0.06u
MU61 net84 D VDD VDD pch w=0.52u l=0.06u
MU62 net66 INCP net124 VDD pch w=0.33u l=0.06u
.ends
.subckt SDFSND0 SI D SE CP SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI79 net82 net120 VSS VSS nch w=0.26u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net177 D net82 VSS nch w=0.26u l=0.06u
MI100-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.15u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI95-M_u2 QN d4 VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.15u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI100-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.2u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI95-M_u3 QN d4 VDD VDD pch w=0.26u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI101 net104 net120 net131 VDD pch w=0.15u l=0.06u
MI72 net132 SE VDD VDD pch w=0.33u l=0.06u
MI73 net104 D net132 VDD pch w=0.33u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.15u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSND1 SI D SE CP SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI105-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI95-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI105-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI95-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSND2 SI D SE CP SDN Q QN VDD VSS
MI91 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.22u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI105-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI108-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI107-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.195u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI105-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI108-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI107-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSND4 SI D SE CP SDN Q QN VDD VSS
MI91 d4 net0110 d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.22u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 net0110 net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI105-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI118-M_u2 INCP net0110 VSS VSS nch w=0.39u l=0.06u
MI107-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI109-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI117-M_u2 net0110 CP VSS VSS nch w=0.39u l=0.06u
MI110-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI111-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.39u l=0.06u
MI93-M_u3 d4 SDN XI93-net6 VSS nch w=0.39u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI105-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI118-M_u3 INCP net0110 VDD VDD pch w=0.52u l=0.06u
MI107-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI108-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI109-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI117-M_u3 net0110 CP VDD VDD pch w=0.52u l=0.06u
MI110-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI111-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI45 d0 net0110 net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 net0110 d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI93-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSNQD0 SI D SE CP SDN Q VDD VSS
MI91 net64 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI79 net82 net120 VSS VSS nch w=0.26u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net177 D net82 VSS nch w=0.26u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.15u l=0.06u
MI101-M_u2 d3 d2 VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI100-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI93-M_u3 net64 SDN XI93-net6 VSS nch w=0.2u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.2u l=0.06u
MI101-M_u3 d3 d2 VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI100-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.15u l=0.06u
MI72 net132 SE VDD VDD pch w=0.33u l=0.06u
MI73 net104 D net132 VDD pch w=0.33u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.15u l=0.06u
MI97 net64 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 net64 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 net64 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSNQD1 SI D SE CP SDN Q VDD VSS
MI91 net068 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI106-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI93-M_u3 net068 SDN XI93-net6 VSS nch w=0.2u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI106-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI105 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 net068 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 net068 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 net068 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSNQD2 SI D SE CP SDN Q VDD VSS
MI91 net075 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI99-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI94-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI105-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI93-M_u3 net075 SDN XI93-net6 VSS nch w=0.2u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI99-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI94-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI105-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 net075 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 net075 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 net075 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFSNQD4 SI D SE CP SDN Q VDD VSS
MI91 net087 INCPB d2 VSS nch w=0.15u l=0.06u
MI92 d1 INCP d2 VSS nch w=0.39u l=0.06u
MI102 net177 net120 net75 VSS nch w=0.35u l=0.06u
MI48 net72 d1 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net72 VSS nch w=0.15u l=0.06u
MI77 d0 INCPB net177 VSS nch w=0.24u l=0.06u
MI78 net79 SI VSS VSS nch w=0.15u l=0.06u
MI80 net177 SE net79 VSS nch w=0.15u l=0.06u
MI81 net75 D VSS VSS nch w=0.39u l=0.06u
MI108-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI109-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI111-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI103-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI107-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net120 SE VSS VSS nch w=0.195u l=0.06u
MI96_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI96_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI112-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI93-M_u4 XI93-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI93-M_u3 net087 SDN XI93-net6 VSS nch w=0.2u l=0.06u
MI16-M_u4 XI16-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI16-M_u3 d1 SDN XI16-net6 VSS nch w=0.39u l=0.06u
MI108-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI109-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI111-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI103-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI107-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net120 SE VDD VDD pch w=0.26u l=0.06u
MI96_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
