************************************************************************************
* TSMC Library/IP Product
* Filename: tcbn65lp_200a.spi
* Technology: CLN65LP
* Product Type: Standard Cell
* Product Name: tcbn65lp
* Version: 200a
*************************************************************************************
**
*  STATEMENT OF USE
*
*  This information contains confidential and proprietary information of TSMC.
*  No part of this information may be reproduced, transmitted, transcribed,
*  stored in a retrieval system, or translated into any human or computer
*  language, in any form or by any means, electronic, mechanical, magnetic,
*  optical, chemical, manual, or otherwise, without the prior written permission
*  of TSMC.  This information was prepared for informational purpose and is for
*  use by TSMC's customers only.  TSMC reserves the right to make changes in the
*  information at any time and without notice.
*
**************************************************************************************
.GLOBAL VDD VSS VDDL
.PARAM
*.BIPOLAR
*.RESVAL
*.CAPVAL
*.DIOAREA
*.SCALE METER
.subckt AN2D0 A1 A2 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AN2D1 A1 A2 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AN2D2 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net010 A1 X_u2-net6 VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net010 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net010 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN2D4 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u4 X_u2_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u3 p0 A1 X_u2_0-net6 VSS nch w=0.39u l=0.06u
M_u2_1-M_u4 X_u2_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u3 p0 A1 X_u2_1-net6 VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u2 p0 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u1 p0 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u2 p0 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u1 p0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN2D8 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u4 X_u2_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u3 n0 A1 X_u2_0-net6 VSS nch w=0.39u l=0.06u
M_u2_1-M_u4 X_u2_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u3 n0 A1 X_u2_1-net6 VSS nch w=0.39u l=0.06u
M_u2_2-M_u4 X_u2_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u3 n0 A1 X_u2_2-net6 VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u2 n0 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u1 n0 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u2 n0 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u1 n0 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u2 n0 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u1 n0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN2XD1 A1 A2 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.39u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN3D0 A1 A2 A3 Z VDD VSS
M_u4-M_u4 net7 A1 X_u4-net10 VSS nch w=0.195u l=0.06u
M_u4-M_u5 X_u4-net10 A2 X_u4-net13 VSS nch w=0.195u l=0.06u
M_u4-M_u6 X_u4-net13 A3 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u2 Z net7 VSS VSS nch w=0.195u l=0.06u
M_u4-M_u3 net7 A3 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u1 net7 A1 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u2 net7 A2 VDD VDD pch w=0.26u l=0.06u
M_u3-M_u3 Z net7 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AN3D1 A1 A2 A3 Z VDD VSS
M_u4-M_u4 net7 A1 X_u4-net10 VSS nch w=0.195u l=0.06u
M_u4-M_u5 X_u4-net10 A2 X_u4-net13 VSS nch w=0.195u l=0.06u
M_u4-M_u6 X_u4-net13 A3 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u3 net7 A3 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u1 net7 A1 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u2 net7 A2 VDD VDD pch w=0.26u l=0.06u
M_u3-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN3D2 A1 A2 A3 Z VDD VSS
M_u4-M_u4 net15 A1 X_u4-net10 VSS nch w=0.39u l=0.06u
M_u4-M_u5 X_u4-net10 A2 X_u4-net13 VSS nch w=0.39u l=0.06u
M_u4-M_u6 X_u4-net13 A3 VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u2 Z net15 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net15 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u3 net15 A3 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u1 net15 A1 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u2 net15 A2 VDD VDD pch w=0.52u l=0.06u
M_u3_0-M_u3 Z net15 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net15 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN3D4 A1 A2 A3 Z VDD VSS
M_u4_0-M_u4 p0 A1 X_u4_0-net10 VSS nch w=0.39u l=0.06u
M_u4_0-M_u5 X_u4_0-net10 A2 X_u4_0-net13 VSS nch w=0.39u l=0.06u
M_u4_0-M_u6 X_u4_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u4 p0 A1 X_u4_1-net10 VSS nch w=0.39u l=0.06u
M_u4_1-M_u5 X_u4_1-net10 A2 X_u4_1-net13 VSS nch w=0.39u l=0.06u
M_u4_1-M_u6 X_u4_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_0-M_u3 p0 A3 VDD VDD pch w=0.52u l=0.06u
M_u4_0-M_u1 p0 A1 VDD VDD pch w=0.52u l=0.06u
M_u4_0-M_u2 p0 A2 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 p0 A3 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u1 p0 A1 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u2 p0 A2 VDD VDD pch w=0.52u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN3D8 A1 A2 A3 Z VDD VSS
M_u4-M_u4 n0 A1 X_u4-net10 VSS nch w=1.17u l=0.06u
M_u4-M_u5 X_u4-net10 A2 X_u4-net13 VSS nch w=1.17u l=0.06u
M_u4-M_u6 X_u4-net13 A3 VSS VSS nch w=1.17u l=0.06u
M_u3_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u3_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u3 n0 A3 VDD VDD pch w=1.56u l=0.06u
M_u4-M_u1 n0 A1 VDD VDD pch w=1.56u l=0.06u
M_u4-M_u2 n0 A2 VDD VDD pch w=1.56u l=0.06u
M_u3_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN3XD1 A1 A2 A3 Z VDD VSS
M_u4-M_u4 net7 A1 X_u4-net10 VSS nch w=0.39u l=0.06u
M_u4-M_u5 X_u4-net10 A2 X_u4-net13 VSS nch w=0.39u l=0.06u
M_u4-M_u6 X_u4-net13 A3 VSS VSS nch w=0.39u l=0.06u
M_u3-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u3 net7 A3 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u1 net7 A1 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u2 net7 A2 VDD VDD pch w=0.52u l=0.06u
M_u3-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN4D0 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.195u l=0.06u
MU30-M_u5 net6 A1 XU30-net23 VSS nch w=0.195u l=0.06u
MU30-MI0 XU30-net23 A2 XU30-net26 VSS nch w=0.195u l=0.06u
MU30-MI1 XU30-net26 A3 XU30-net29 VSS nch w=0.195u l=0.06u
MU30-MI2 XU30-net29 A4 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.26u l=0.06u
MU30-M_u4 net6 A4 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net6 A3 VDD VDD pch w=0.26u l=0.06u
MU30-M_u2 net6 A2 VDD VDD pch w=0.26u l=0.06u
MU30-M_u1 net6 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AN4D1 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
MU30-M_u5 net6 A1 XU30-net23 VSS nch w=0.195u l=0.06u
MU30-MI0 XU30-net23 A2 XU30-net26 VSS nch w=0.195u l=0.06u
MU30-MI1 XU30-net26 A3 XU30-net29 VSS nch w=0.195u l=0.06u
MU30-MI2 XU30-net29 A4 VSS VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
MU30-M_u4 net6 A4 VDD VDD pch w=0.26u l=0.06u
MU30-M_u3 net6 A3 VDD VDD pch w=0.26u l=0.06u
MU30-M_u2 net6 A2 VDD VDD pch w=0.26u l=0.06u
MU30-M_u1 net6 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AN4D2 A1 A2 A3 A4 Z VDD VSS
MU18_0-M_u2 Z net19 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z net19 VSS VSS nch w=0.39u l=0.06u
MU20-M_u5 net19 A1 XU20-net23 VSS nch w=0.39u l=0.06u
MU20-MI0 XU20-net23 A2 XU20-net26 VSS nch w=0.39u l=0.06u
MU20-MI1 XU20-net26 A3 XU20-net29 VSS nch w=0.39u l=0.06u
MU20-MI2 XU20-net29 A4 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u3 Z net19 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z net19 VDD VDD pch w=0.52u l=0.06u
MU20-M_u4 net19 A4 VDD VDD pch w=0.52u l=0.06u
MU20-M_u3 net19 A3 VDD VDD pch w=0.52u l=0.06u
MU20-M_u2 net19 A2 VDD VDD pch w=0.52u l=0.06u
MU20-M_u1 net19 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN4D4 A1 A2 A3 A4 Z VDD VSS
MU18_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU30_0-M_u5 n0 A1 XU30_0-net23 VSS nch w=0.39u l=0.06u
MU30_0-MI0 XU30_0-net23 A2 XU30_0-net26 VSS nch w=0.39u l=0.06u
MU30_0-MI1 XU30_0-net26 A3 XU30_0-net29 VSS nch w=0.39u l=0.06u
MU30_0-MI2 XU30_0-net29 A4 VSS VSS nch w=0.39u l=0.06u
MU30_1-M_u5 n0 A1 XU30_1-net23 VSS nch w=0.39u l=0.06u
MU30_1-MI0 XU30_1-net23 A2 XU30_1-net26 VSS nch w=0.39u l=0.06u
MU30_1-MI1 XU30_1-net26 A3 XU30_1-net29 VSS nch w=0.39u l=0.06u
MU30_1-MI2 XU30_1-net29 A4 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU30_0-M_u4 n0 A4 VDD VDD pch w=0.52u l=0.06u
MU30_0-M_u3 n0 A3 VDD VDD pch w=0.52u l=0.06u
MU30_0-M_u2 n0 A2 VDD VDD pch w=0.52u l=0.06u
MU30_0-M_u1 n0 A1 VDD VDD pch w=0.52u l=0.06u
MU30_1-M_u4 n0 A4 VDD VDD pch w=0.52u l=0.06u
MU30_1-M_u3 n0 A3 VDD VDD pch w=0.52u l=0.06u
MU30_1-M_u2 n0 A2 VDD VDD pch w=0.52u l=0.06u
MU30_1-M_u1 n0 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AN4D8 A1 A2 A3 A4 Z VDD VSS
MU18_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU18_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU30-M_u5 n0 A1 XU30-net23 VSS nch w=1.17u l=0.06u
MU30-MI0 XU30-net23 A2 XU30-net26 VSS nch w=1.17u l=0.06u
MU30-MI1 XU30-net26 A3 XU30-net29 VSS nch w=1.17u l=0.06u
MU30-MI2 XU30-net29 A4 VSS VSS nch w=1.17u l=0.06u
MU18_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU18_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU30-M_u4 n0 A4 VDD VDD pch w=1.56u l=0.06u
MU30-M_u3 n0 A3 VDD VDD pch w=1.56u l=0.06u
MU30-M_u2 n0 A2 VDD VDD pch w=1.56u l=0.06u
MU30-M_u1 n0 A1 VDD VDD pch w=1.56u l=0.06u
.ends
.subckt AN4XD1 A1 A2 A3 A4 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
MU30-M_u5 net6 A1 XU30-net23 VSS nch w=0.39u l=0.06u
MU30-MI0 XU30-net23 A2 XU30-net26 VSS nch w=0.39u l=0.06u
MU30-MI1 XU30-net26 A3 XU30-net29 VSS nch w=0.39u l=0.06u
MU30-MI2 XU30-net29 A4 VSS VSS nch w=0.39u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
MU30-M_u4 net6 A4 VDD VDD pch w=0.52u l=0.06u
MU30-M_u3 net6 A3 VDD VDD pch w=0.52u l=0.06u
MU30-M_u2 net6 A2 VDD VDD pch w=0.52u l=0.06u
MU30-M_u1 net6 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ANTENNA I VDD VSS
DI3 VSS I ndio area=0.1066p pj=1.34u
.ends
.subckt AO211D0 A1 A2 B C Z VDD VSS
MI8-M_u3 Z net27 VDD VDD pch w=0.26u l=0.06u
M_u3 net11 A1 net27 VDD pch w=0.26u l=0.06u
MI0 net11 A2 net27 VDD pch w=0.26u l=0.06u
MI16-MI12 net11 B XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 C VDD VDD pch w=0.26u l=0.06u
MI8-M_u2 Z net27 VSS VSS nch w=0.195u l=0.06u
M_u12 net27 C VSS VSS nch w=0.195u l=0.06u
M_u13 net27 B VSS VSS nch w=0.195u l=0.06u
MI12-M_u10 net27 A1 XI12-net17 VSS nch w=0.195u l=0.06u
MI12-M_u11 XI12-net17 A2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AO211D1 A1 A2 B C Z VDD VSS
MI8-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u3 net11 A1 net27 VDD pch w=0.52u l=0.06u
MI0 net11 A2 net27 VDD pch w=0.52u l=0.06u
MI16-MI12 net11 B XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 C VDD VDD pch w=0.52u l=0.06u
MI12-M_u10 net27 A1 XI12-net17 VSS nch w=0.39u l=0.06u
MI12-M_u11 XI12-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u12 net27 C VSS VSS nch w=0.39u l=0.06u
M_u13 net27 B VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO211D2 A1 A2 B C Z VDD VSS
MI16-MI12 net11 B XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 C VDD VDD pch w=0.52u l=0.06u
MI8_0-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u3 net11 A1 net27 VDD pch w=0.52u l=0.06u
MI0 net11 A2 net27 VDD pch w=0.52u l=0.06u
MI12-M_u10 net27 A1 XI12-net17 VSS nch w=0.39u l=0.06u
MI12-M_u11 XI12-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u12 net27 C VSS VSS nch w=0.39u l=0.06u
M_u13 net27 B VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO211D4 A1 A2 B C Z VDD VSS
MI8_0-M_u3 Z net24 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net24 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z net24 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z net24 VDD VDD pch w=0.52u l=0.06u
MI2 net11 A2 net24 VDD pch w=1.04u l=0.06u
M_u3 net11 A1 net24 VDD pch w=1.04u l=0.06u
MI16_0-MI12 net11 B XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 C VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 net11 B XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 C VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u10 net24 A1 XI12_0-net17 VSS nch w=0.39u l=0.06u
MI12_0-M_u11 XI12_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u10 net24 A1 XI12_1-net17 VSS nch w=0.39u l=0.06u
MI12_1-M_u11 XI12_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u2 Z net24 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net24 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z net24 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z net24 VSS VSS nch w=0.39u l=0.06u
M_u12_0 net24 C VSS VSS nch w=0.39u l=0.06u
M_u12_1 net24 C VSS VSS nch w=0.39u l=0.06u
M_u13_0 net24 B VSS VSS nch w=0.39u l=0.06u
M_u13_1 net24 B VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO21D0 A1 A2 B Z VDD VSS
MI12 net32 A2 VSS VSS nch w=0.195u l=0.06u
MI11 net59 A1 net32 VSS nch w=0.195u l=0.06u
MI6 net59 B VSS VSS nch w=0.195u l=0.06u
MI8-M_u2 Z net59 VSS VSS nch w=0.195u l=0.06u
MI8-M_u3 Z net59 VDD VDD pch w=0.26u l=0.06u
MI10 net59 A1 net22 VDD pch w=0.26u l=0.06u
MI9 net59 A2 net22 VDD pch w=0.26u l=0.06u
M_u2 net22 B VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AO21D1 A1 A2 B Z VDD VSS
MI7 net32 A2 VSS VSS nch w=0.39u l=0.06u
M_u7 net59 A1 net32 VSS nch w=0.39u l=0.06u
MI6 net59 B VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 Z net59 VSS VSS nch w=0.39u l=0.06u
MI8-M_u3 Z net59 VDD VDD pch w=0.52u l=0.06u
M_u3 net22 A1 net59 VDD pch w=0.52u l=0.06u
M_u4 net22 A2 net59 VDD pch w=0.52u l=0.06u
M_u2 net22 B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AO21D2 A1 A2 B Z VDD VSS
MI7 net32 A2 VSS VSS nch w=0.39u l=0.06u
M_u7 net59 A1 net32 VSS nch w=0.39u l=0.06u
MI6 net59 B VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u2 Z net59 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net59 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u3 Z net59 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net59 VDD VDD pch w=0.52u l=0.06u
M_u3 net22 A1 net59 VDD pch w=0.52u l=0.06u
M_u4 net22 A2 net59 VDD pch w=0.52u l=0.06u
M_u2 net22 B VDD VDD pch w=0.52u l=0.06u
.ends
.subckt AO21D4 A1 A2 B Z VDD VSS
MI7_0 net36<0> A2 VSS VSS nch w=0.39u l=0.06u
MI7_1 net36<1> A2 VSS VSS nch w=0.39u l=0.06u
M_u7_0 p0 A1 net36<0> VSS nch w=0.39u l=0.06u
M_u7_1 p0 A1 net36<1> VSS nch w=0.39u l=0.06u
MI6 p0 B VSS VSS nch w=0.78u l=0.06u
MI8_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3 net32 A1 p0 VDD pch w=1.04u l=0.06u
MI11 net32 A2 p0 VDD pch w=1.04u l=0.06u
MI12 VDD B net32 VDD pch w=1.04u l=0.06u
.ends
.subckt AO221D0 A1 A2 B1 B2 C Z VDD VSS
MI8-M_u3 Z net31 VDD VDD pch w=0.26u l=0.06u
MI10 net30 A1 net31 VDD pch w=0.26u l=0.06u
MI9 net30 A2 net31 VDD pch w=0.26u l=0.06u
MU22 VDD C net36 VDD pch w=0.26u l=0.06u
MI6 net36 B2 net30 VDD pch w=0.26u l=0.06u
MI7 net36 B1 net30 VDD pch w=0.26u l=0.06u
MI8-M_u2 Z net31 VSS VSS nch w=0.195u l=0.06u
MU20 net31 C VSS VSS nch w=0.195u l=0.06u
MI17-M_u10 net31 B1 XI17-net17 VSS nch w=0.195u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.195u l=0.06u
MI1-M_u10 net31 A1 XI1-net17 VSS nch w=0.195u l=0.06u
MI1-M_u11 XI1-net17 A2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AO221D1 A1 A2 B1 B2 C Z VDD VSS
MI8-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MI5 net30 A1 net31 VDD pch w=0.52u l=0.06u
MI4 net30 A2 net31 VDD pch w=0.52u l=0.06u
MU22 VDD C net36 VDD pch w=0.52u l=0.06u
MI2 net36 B2 net30 VDD pch w=0.52u l=0.06u
MI3 net36 B1 net30 VDD pch w=0.52u l=0.06u
MI8-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MU20 net31 C VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 net31 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u10 net31 A1 XI1-net17 VSS nch w=0.39u l=0.06u
MI1-M_u11 XI1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO221D2 A1 A2 B1 B2 C Z VDD VSS
MI8_0-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net31 VDD VDD pch w=0.52u l=0.06u
MI5 net30 A1 net31 VDD pch w=0.52u l=0.06u
MI4 net30 A2 net31 VDD pch w=0.52u l=0.06u
MU22 VDD C net36 VDD pch w=0.52u l=0.06u
MI2 net36 B2 net30 VDD pch w=0.52u l=0.06u
MI3 net36 B1 net30 VDD pch w=0.52u l=0.06u
MI8_0-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net31 VSS VSS nch w=0.39u l=0.06u
MU20 net31 C VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 net31 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u10 net31 A1 XI1-net17 VSS nch w=0.39u l=0.06u
MI1-M_u11 XI1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO221D4 A1 A2 B1 B2 C Z VDD VSS
MI8_0-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI14 net30 A1 net43 VDD pch w=1.04u l=0.06u
MI13 net30 A2 net43 VDD pch w=1.04u l=0.06u
MI10 VDD C net36 VDD pch w=1.04u l=0.06u
MI11 net36 B2 net30 VDD pch w=1.04u l=0.06u
MI12 net36 B1 net30 VDD pch w=1.04u l=0.06u
MI8_0-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MU20_0 net43 C VSS VSS nch w=0.39u l=0.06u
MU20_1 net43 C VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u10 net43 B1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 net43 B1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u10 net43 A1 XI1_0-net17 VSS nch w=0.39u l=0.06u
MI1_0-M_u11 XI1_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u10 net43 A1 XI1_1-net17 VSS nch w=0.39u l=0.06u
MI1_1-M_u11 XI1_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO222D0 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI15-M_u3 Z net39 VDD VDD pch w=0.26u l=0.06u
MI16 VDD C1 net22 VDD pch w=0.26u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.26u l=0.06u
MI20 net16 A1 net39 VDD pch w=0.26u l=0.06u
MI19 net16 A2 net39 VDD pch w=0.26u l=0.06u
MI18 net22 B1 net16 VDD pch w=0.26u l=0.06u
MI17 net22 B2 net16 VDD pch w=0.26u l=0.06u
MI15-M_u2 Z net39 VSS VSS nch w=0.195u l=0.06u
MI22-M_u10 net39 C1 XI22-net17 VSS nch w=0.195u l=0.06u
MI22-M_u11 XI22-net17 C2 VSS VSS nch w=0.195u l=0.06u
MI6-M_u10 net39 A1 XI6-net17 VSS nch w=0.195u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.195u l=0.06u
MI21-M_u10 net39 B1 XI21-net17 VSS nch w=0.195u l=0.06u
MI21-M_u11 XI21-net17 B2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AO222D1 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI15-M_u3 Z net39 VDD VDD pch w=0.52u l=0.06u
MI8 VDD C1 net22 VDD pch w=0.52u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.52u l=0.06u
MI12 net16 A1 net39 VDD pch w=0.52u l=0.06u
MI11 net16 A2 net39 VDD pch w=0.52u l=0.06u
MI10 net22 B1 net16 VDD pch w=0.52u l=0.06u
MI9 net22 B2 net16 VDD pch w=0.52u l=0.06u
MI15-M_u2 Z net39 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 net39 C1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6-M_u10 net39 A1 XI6-net17 VSS nch w=0.39u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u10 net39 B1 XI13-net17 VSS nch w=0.39u l=0.06u
MI13-M_u11 XI13-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO222D2 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI15_0-M_u3 Z net39 VDD VDD pch w=0.52u l=0.06u
MI15_1-M_u3 Z net39 VDD VDD pch w=0.52u l=0.06u
MI8 VDD C1 net22 VDD pch w=0.52u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.52u l=0.06u
MI12 net16 A1 net39 VDD pch w=0.52u l=0.06u
MI11 net16 A2 net39 VDD pch w=0.52u l=0.06u
MI10 net22 B1 net16 VDD pch w=0.52u l=0.06u
MI9 net22 B2 net16 VDD pch w=0.52u l=0.06u
MI15_0-M_u2 Z net39 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u2 Z net39 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 net39 C1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6-M_u10 net39 A1 XI6-net17 VSS nch w=0.39u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u10 net39 B1 XI13-net17 VSS nch w=0.39u l=0.06u
MI13-M_u11 XI13-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO222D4 A1 A2 B1 B2 C1 C2 Z VDD VSS
MI15_0-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI15_1-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI15_2-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI15_3-M_u3 Z net33 VDD VDD pch w=0.52u l=0.06u
MI27 net16 A1 net33 VDD pch w=1.04u l=0.06u
MI23 VDD C1 net22 VDD pch w=1.04u l=0.06u
MU27 VDD C2 net22 VDD pch w=1.04u l=0.06u
MI26 net16 A2 net33 VDD pch w=1.04u l=0.06u
MI25 net22 B1 net16 VDD pch w=1.04u l=0.06u
MI24 net22 B2 net16 VDD pch w=1.04u l=0.06u
MI15_0-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI15_2-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI15_3-M_u2 Z net33 VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u10 net33 C1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 net33 C1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6_0-M_u10 net33 A1 XI6_0-net17 VSS nch w=0.39u l=0.06u
MI6_0-M_u11 XI6_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI6_1-M_u10 net33 A1 XI6_1-net17 VSS nch w=0.39u l=0.06u
MI6_1-M_u11 XI6_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI16_0-M_u10 net33 B1 XI16_0-net17 VSS nch w=0.39u l=0.06u
MI16_0-M_u11 XI16_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI16_1-M_u10 net33 B1 XI16_1-net17 VSS nch w=0.39u l=0.06u
MI16_1-M_u11 XI16_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO22D0 A1 A2 B1 B2 Z VDD VSS
MI23 net29 A2 VSS VSS nch w=0.195u l=0.06u
MI16 net26 B1 net20 VSS nch w=0.195u l=0.06u
MI22 net20 B2 VSS VSS nch w=0.195u l=0.06u
MI24 net26 A1 net29 VSS nch w=0.195u l=0.06u
MI8-M_u2 Z net26 VSS VSS nch w=0.195u l=0.06u
MI8-M_u3 Z net26 VDD VDD pch w=0.26u l=0.06u
MI20 net26 A1 net40 VDD pch w=0.26u l=0.06u
MI19 net26 A2 net40 VDD pch w=0.26u l=0.06u
M_u2 net40 B2 VDD VDD pch w=0.26u l=0.06u
MI21 net40 B1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt AO22D1 A1 A2 B1 B2 Z VDD VSS
MI28 net52 A1 net37 VSS nch w=0.39u l=0.06u
MI21 net52 B1 net31 VSS nch w=0.39u l=0.06u
MI22 net31 B2 VSS VSS nch w=0.39u l=0.06u
MI29 net37 A2 VSS VSS nch w=0.39u l=0.06u
MI20-M_u2 Z net52 VSS VSS nch w=0.39u l=0.06u
MI20-M_u3 Z net52 VDD VDD pch w=0.52u l=0.06u
MI15 net54 B2 VDD VDD pch w=0.52u l=0.06u
MI18 net52 A2 net54 VDD pch w=0.52u l=0.06u
MI17 net54 B1 VDD VDD pch w=0.52u l=0.06u
MI19 net52 A1 net54 VDD pch w=0.52u l=0.06u
.ends
.subckt AO22D2 A1 A2 B1 B2 Z VDD VSS
MI28 net52 A1 net37 VSS nch w=0.39u l=0.06u
MI21 net52 B1 net31 VSS nch w=0.39u l=0.06u
MI22 net31 B2 VSS VSS nch w=0.39u l=0.06u
MI29 net37 A2 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u2 Z net52 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u2 Z net52 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u3 Z net52 VDD VDD pch w=0.52u l=0.06u
MI20_1-M_u3 Z net52 VDD VDD pch w=0.52u l=0.06u
MI15 net54 B2 VDD VDD pch w=0.52u l=0.06u
MI18 net52 A2 net54 VDD pch w=0.52u l=0.06u
MI17 net54 B1 VDD VDD pch w=0.52u l=0.06u
MI19 net52 A1 net54 VDD pch w=0.52u l=0.06u
.ends
.subckt AO22D4 A1 A2 B1 B2 Z VDD VSS
MI40_0 net29<0> A2 VSS VSS nch w=0.39u l=0.06u
MI40_1 net29<1> A2 VSS VSS nch w=0.39u l=0.06u
MI41_0 net46 A1 net29<0> VSS nch w=0.39u l=0.06u
MI41_1 net46 A1 net29<1> VSS nch w=0.39u l=0.06u
MI39_0 net34<0> B2 VSS VSS nch w=0.39u l=0.06u
MI39_1 net34<1> B2 VSS VSS nch w=0.39u l=0.06u
MI34_0 net46 B1 net34<0> VSS nch w=0.39u l=0.06u
MI34_1 net46 B1 net34<1> VSS nch w=0.39u l=0.06u
MI20_0-M_u2 Z net46 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u2 Z net46 VSS VSS nch w=0.39u l=0.06u
MI20_2-M_u2 Z net46 VSS VSS nch w=0.39u l=0.06u
MI20_3-M_u2 Z net46 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u3 Z net46 VDD VDD pch w=0.52u l=0.06u
MI20_1-M_u3 Z net46 VDD VDD pch w=0.52u l=0.06u
MI20_2-M_u3 Z net46 VDD VDD pch w=0.52u l=0.06u
MI20_3-M_u3 Z net46 VDD VDD pch w=0.52u l=0.06u
MI32 net54 B2 VDD VDD pch w=1.04u l=0.06u
MI43 net46 A2 net54 VDD pch w=1.04u l=0.06u
MI42 net54 B1 VDD VDD pch w=1.04u l=0.06u
MI44 net46 A1 net54 VDD pch w=1.04u l=0.06u
.ends
.subckt AO31D0 A1 A2 A3 B Z VDD VSS
MI8-M_u3 Z net26 VDD VDD pch w=0.26u l=0.06u
MI3 net26 A1 net19 VDD pch w=0.26u l=0.06u
MI2 net26 A2 net19 VDD pch w=0.26u l=0.06u
MI1 net26 A3 net19 VDD pch w=0.26u l=0.06u
MU20 net19 B VDD VDD pch w=0.26u l=0.06u
MI8-M_u2 Z net26 VSS VSS nch w=0.195u l=0.06u
MU14 net26 B VSS VSS nch w=0.195u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI20-M_u10 net26 A1 XI20-net17 VSS nch w=0.195u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.195u l=0.06u
.ends
.subckt AO31D1 A1 A2 A3 B Z VDD VSS
MI8-M_u3 Z net26 VDD VDD pch w=0.52u l=0.06u
MU17 net26 A1 net19 VDD pch w=0.52u l=0.06u
MU18 net26 A3 net19 VDD pch w=0.52u l=0.06u
MU16 net26 A2 net19 VDD pch w=0.52u l=0.06u
MU20 net19 B VDD VDD pch w=0.52u l=0.06u
MI8-M_u2 Z net26 VSS VSS nch w=0.39u l=0.06u
MU14 net26 B VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 net26 A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AO31D2 A1 A2 A3 B Z VDD VSS
MI8_0-M_u3 Z net26 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net26 VDD VDD pch w=0.52u l=0.06u
MU17 net26 A1 net19 VDD pch w=0.52u l=0.06u
MU18 net26 A3 net19 VDD pch w=0.52u l=0.06u
MU16 net26 A2 net19 VDD pch w=0.52u l=0.06u
MU20 net19 B VDD VDD pch w=0.52u l=0.06u
MI8_0-M_u2 Z net26 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net26 VSS VSS nch w=0.39u l=0.06u
MU14 net26 B VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 net26 A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AO31D4 A1 A2 A3 B Z VDD VSS
MI8_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI6 p0 A1 net19 VDD pch w=1.04u l=0.06u
MI1 net19 B VDD VDD pch w=1.04u l=0.06u
MI4 p0 A3 net19 VDD pch w=1.04u l=0.06u
MI5 p0 A2 net19 VDD pch w=1.04u l=0.06u
MI8_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU14_0 p0 B VSS VSS nch w=0.39u l=0.06u
MU14_1 p0 B VSS VSS nch w=0.39u l=0.06u
MI20_0-MI12 XI20_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u10 p0 A1 XI20_0-net17 VSS nch w=0.39u l=0.06u
MI20_0-M_u11 XI20_0-net17 A2 XI20_0-net13 VSS nch w=0.39u l=0.06u
MI20_1-MI12 XI20_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u10 p0 A1 XI20_1-net17 VSS nch w=0.39u l=0.06u
MI20_1-M_u11 XI20_1-net17 A2 XI20_1-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AO32D0 A1 A2 A3 B1 B2 Z VDD VSS
MI8-M_u3 Z net27 VDD VDD pch w=0.26u l=0.06u
MI4 net27 A1 net23 VDD pch w=0.26u l=0.06u
MI2 net27 A3 net23 VDD pch w=0.26u l=0.06u
MI3 net27 A2 net23 VDD pch w=0.26u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.26u l=0.06u
MI1 net23 B2 VDD VDD pch w=0.26u l=0.06u
MI8-M_u2 Z net27 VSS VSS nch w=0.195u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI20-M_u10 net27 A1 XI20-net17 VSS nch w=0.195u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.195u l=0.06u
MI17-M_u10 net27 B1 XI17-net17 VSS nch w=0.195u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AO32D1 A1 A2 A3 B1 B2 Z VDD VSS
MI8-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MU17 net27 A1 net23 VDD pch w=0.52u l=0.06u
MU18 net27 A3 net23 VDD pch w=0.52u l=0.06u
MU16 net27 A2 net23 VDD pch w=0.52u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.52u l=0.06u
MU19 net23 B2 VDD VDD pch w=0.52u l=0.06u
MI8-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 net27 A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
MI17-M_u10 net27 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO32D2 A1 A2 A3 B1 B2 Z VDD VSS
MI8_0-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MU17 net27 A1 net23 VDD pch w=0.52u l=0.06u
MU18 net27 A3 net23 VDD pch w=0.52u l=0.06u
MU16 net27 A2 net23 VDD pch w=0.52u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.52u l=0.06u
MU19 net23 B2 VDD VDD pch w=0.52u l=0.06u
MI8_0-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 net27 A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
MI17-M_u10 net27 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO32D4 A1 A2 A3 B1 B2 Z VDD VSS
MI8_0-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
MI9 net27 A1 net23 VDD pch w=1.04u l=0.06u
MI6 net27 A3 net23 VDD pch w=1.04u l=0.06u
MI7 net27 A2 net23 VDD pch w=1.04u l=0.06u
MI1 net23 B1 VDD VDD pch w=1.04u l=0.06u
MI5 net23 B2 VDD VDD pch w=1.04u l=0.06u
MI8_0-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
MI20_0-MI12 XI20_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u10 net27 A1 XI20_0-net17 VSS nch w=0.39u l=0.06u
MI20_0-M_u11 XI20_0-net17 A2 XI20_0-net13 VSS nch w=0.39u l=0.06u
MI20_1-MI12 XI20_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u10 net27 A1 XI20_1-net17 VSS nch w=0.39u l=0.06u
MI20_1-M_u11 XI20_1-net17 A2 XI20_1-net13 VSS nch w=0.39u l=0.06u
MI17_0-M_u10 net27 B1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 net27 B1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AO33D0 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI8-M_u3 Z net30 VDD VDD pch w=0.26u l=0.06u
MI12 net40 A2 net30 VDD pch w=0.26u l=0.06u
MI13 net40 A1 net30 VDD pch w=0.26u l=0.06u
M_u16 VDD B3 net40 VDD pch w=0.26u l=0.06u
MI10 VDD B1 net40 VDD pch w=0.26u l=0.06u
MI11 net40 A3 net30 VDD pch w=0.26u l=0.06u
MI9 VDD B2 net40 VDD pch w=0.26u l=0.06u
MI8-M_u2 Z net30 VSS VSS nch w=0.195u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI14-M_u10 net30 A1 XI14-net17 VSS nch w=0.195u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=0.195u l=0.06u
MI7-MI12 XI7-net13 B3 VSS VSS nch w=0.195u l=0.06u
MI7-M_u10 net30 B1 XI7-net17 VSS nch w=0.195u l=0.06u
MI7-M_u11 XI7-net17 B2 XI7-net13 VSS nch w=0.195u l=0.06u
.ends
.subckt AO33D1 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI8-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MI6 net40 A1 net30 VDD pch w=0.52u l=0.06u
MI13 VDD B3 net40 VDD pch w=0.52u l=0.06u
MI11 VDD B1 net40 VDD pch w=0.52u l=0.06u
MI10 net40 A3 net30 VDD pch w=0.52u l=0.06u
MI9 net40 A2 net30 VDD pch w=0.52u l=0.06u
MI12 VDD B2 net40 VDD pch w=0.52u l=0.06u
MI8-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 net30 A1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=0.39u l=0.06u
MI15-MI12 XI15-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI15-M_u10 net30 B1 XI15-net17 VSS nch w=0.39u l=0.06u
MI15-M_u11 XI15-net17 B2 XI15-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AO33D2 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI8_0-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net30 VDD VDD pch w=0.52u l=0.06u
MI6 net40 A1 net30 VDD pch w=0.52u l=0.06u
MI13 VDD B3 net40 VDD pch w=0.52u l=0.06u
MI11 VDD B1 net40 VDD pch w=0.52u l=0.06u
MI10 net40 A3 net30 VDD pch w=0.52u l=0.06u
MI9 net40 A2 net30 VDD pch w=0.52u l=0.06u
MI12 VDD B2 net40 VDD pch w=0.52u l=0.06u
MI8_0-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net30 VSS VSS nch w=0.39u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 net30 A1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=0.39u l=0.06u
MI15-MI12 XI15-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI15-M_u10 net30 B1 XI15-net17 VSS nch w=0.39u l=0.06u
MI15-M_u11 XI15-net17 B2 XI15-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AO33D4 A1 A2 A3 B1 B2 B3 Z VDD VSS
MI8_0-M_u3 Z net34 VDD VDD pch w=0.52u l=0.06u
MI8_1-M_u3 Z net34 VDD VDD pch w=0.52u l=0.06u
MI8_2-M_u3 Z net34 VDD VDD pch w=0.52u l=0.06u
MI8_3-M_u3 Z net34 VDD VDD pch w=0.52u l=0.06u
MI24 VDD B1 net40 VDD pch w=1.04u l=0.06u
MI27 net40 A1 net34 VDD pch w=1.04u l=0.06u
MI25 net40 A3 net34 VDD pch w=1.04u l=0.06u
MI26 net40 A2 net34 VDD pch w=1.04u l=0.06u
MI13 VDD B3 net40 VDD pch w=1.04u l=0.06u
MI23 VDD B2 net40 VDD pch w=1.04u l=0.06u
MI8_0-M_u2 Z net34 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 Z net34 VSS VSS nch w=0.39u l=0.06u
MI8_2-M_u2 Z net34 VSS VSS nch w=0.39u l=0.06u
MI8_3-M_u2 Z net34 VSS VSS nch w=0.39u l=0.06u
MI14_0-MI12 XI14_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14_0-M_u10 net34 A1 XI14_0-net17 VSS nch w=0.39u l=0.06u
MI14_0-M_u11 XI14_0-net17 A2 XI14_0-net13 VSS nch w=0.39u l=0.06u
MI14_1-MI12 XI14_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14_1-M_u10 net34 A1 XI14_1-net17 VSS nch w=0.39u l=0.06u
MI14_1-M_u11 XI14_1-net17 A2 XI14_1-net13 VSS nch w=0.39u l=0.06u
MI28_0-MI12 XI28_0-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI28_0-M_u10 net34 B1 XI28_0-net17 VSS nch w=0.39u l=0.06u
MI28_0-M_u11 XI28_0-net17 B2 XI28_0-net13 VSS nch w=0.39u l=0.06u
MI28_1-MI12 XI28_1-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI28_1-M_u10 net34 B1 XI28_1-net17 VSS nch w=0.39u l=0.06u
MI28_1-M_u11 XI28_1-net17 B2 XI28_1-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI211D0 A1 A2 B C ZN VDD VSS
M_u3 net11 A1 ZN VDD pch w=0.26u l=0.06u
MI0 net11 A2 ZN VDD pch w=0.26u l=0.06u
MI16-MI12 net11 B XI16-net11 VDD pch w=0.26u l=0.06u
MI16-MI13 XI16-net11 C VDD VDD pch w=0.26u l=0.06u
MI2 ZN C VSS VSS nch w=0.195u l=0.06u
M_u13 ZN B VSS VSS nch w=0.195u l=0.06u
MI12-M_u10 ZN A1 XI12-net17 VSS nch w=0.195u l=0.06u
MI12-M_u11 XI12-net17 A2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AOI211D1 A1 A2 B C ZN VDD VSS
M_u3 net71 A1 ZN VDD pch w=0.52u l=0.06u
M_u2 net71 A2 ZN VDD pch w=0.52u l=0.06u
MI19-MI12 net71 B XI19-net11 VDD pch w=0.52u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=0.52u l=0.06u
M_u12 ZN C VSS VSS nch w=0.39u l=0.06u
M_u13 ZN B VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 ZN A1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI211D2 A1 A2 B C ZN VDD VSS
MI19-MI12 net34 B XI19-net11 VDD pch w=0.52u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=0.52u l=0.06u
MI2-MI12 net34 B XI2-net11 VDD pch w=0.52u l=0.06u
MI2-MI13 XI2-net11 C VDD VDD pch w=0.52u l=0.06u
M_u3_0 net34 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_1 net34 A1 ZN VDD pch w=0.52u l=0.06u
M_u2_0 net34 A2 ZN VDD pch w=0.52u l=0.06u
M_u2_1 net34 A2 ZN VDD pch w=0.52u l=0.06u
M_u12_0 ZN C VSS VSS nch w=0.39u l=0.06u
M_u12_1 ZN C VSS VSS nch w=0.39u l=0.06u
M_u13_0 ZN B VSS VSS nch w=0.39u l=0.06u
M_u13_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u10 ZN A1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 ZN A1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI211D4 A1 A2 B C ZN VDD VSS
M_u3 net030 A1 ZN VDD pch w=2.08u l=0.06u
MI3 net030 A2 ZN VDD pch w=2.08u l=0.06u
MI19-MI12 net030 B XI19-net11 VDD pch w=2.08u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=2.08u l=0.06u
M_u12_0 ZN C VSS VSS nch w=0.39u l=0.06u
M_u12_1 ZN C VSS VSS nch w=0.39u l=0.06u
M_u12_2 ZN C VSS VSS nch w=0.39u l=0.06u
M_u12_3 ZN C VSS VSS nch w=0.39u l=0.06u
MI4_0 ZN B VSS VSS nch w=0.39u l=0.06u
MI4_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI4_2 ZN B VSS VSS nch w=0.39u l=0.06u
MI4_3 ZN B VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 ZN A1 XI17-net17 VSS nch w=1.56u l=0.06u
MI17-M_u11 XI17-net17 A2 VSS VSS nch w=1.56u l=0.06u
.ends
.subckt AOI211XD0 A1 A2 B C ZN VDD VSS
M_u3 net11 A1 ZN VDD pch w=0.52u l=0.06u
MI0 net11 A2 ZN VDD pch w=0.52u l=0.06u
MI16-MI12 net11 B XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 C VDD VDD pch w=0.52u l=0.06u
MI12-M_u10 ZN A1 XI12-net17 VSS nch w=0.195u l=0.06u
MI12-M_u11 XI12-net17 A2 VSS VSS nch w=0.195u l=0.06u
M_u12 ZN C VSS VSS nch w=0.195u l=0.06u
M_u13 ZN B VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AOI211XD1 A1 A2 B C ZN VDD VSS
M_u3 net030 A1 ZN VDD pch w=1.04u l=0.06u
MI1 net030 A2 ZN VDD pch w=1.04u l=0.06u
MI19-MI12 net030 B XI19-net11 VDD pch w=1.04u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=1.04u l=0.06u
M_u12 ZN C VSS VSS nch w=0.39u l=0.06u
M_u13 ZN B VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 ZN A1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI211XD2 A1 A2 B C ZN VDD VSS
MI17-M_u10 ZN A1 XI17-net17 VSS nch w=0.78u l=0.06u
MI17-M_u11 XI17-net17 A2 VSS VSS nch w=0.78u l=0.06u
M_u12_0 ZN C VSS VSS nch w=0.39u l=0.06u
M_u12_1 ZN C VSS VSS nch w=0.39u l=0.06u
M_u13_0 ZN B VSS VSS nch w=0.39u l=0.06u
M_u13_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI19-MI12 net026 B XI19-net11 VDD pch w=2.08u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=2.08u l=0.06u
M_u3_0 net026 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_1 net026 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_2 net026 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_3 net026 A1 ZN VDD pch w=0.52u l=0.06u
MI3_0 net026 A2 ZN VDD pch w=0.52u l=0.06u
MI3_1 net026 A2 ZN VDD pch w=0.52u l=0.06u
MI3_2 net026 A2 ZN VDD pch w=0.52u l=0.06u
MI3_3 net026 A2 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt AOI211XD4 A1 A2 B C ZN VDD VSS
MI17-M_u10 ZN A1 XI17-net17 VSS nch w=1.56u l=0.06u
MI17-M_u11 XI17-net17 A2 VSS VSS nch w=1.56u l=0.06u
MI3_0 ZN C VSS VSS nch w=0.39u l=0.06u
MI3_1 ZN C VSS VSS nch w=0.39u l=0.06u
MI3_2 ZN C VSS VSS nch w=0.39u l=0.06u
MI3_3 ZN C VSS VSS nch w=0.39u l=0.06u
MI2_0 ZN B VSS VSS nch w=0.39u l=0.06u
MI2_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI2_2 ZN B VSS VSS nch w=0.39u l=0.06u
MI2_3 ZN B VSS VSS nch w=0.39u l=0.06u
M_u3_0 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_1 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_2 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_3 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_4 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_5 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_6 net038 A1 ZN VDD pch w=0.52u l=0.06u
M_u3_7 net038 A1 ZN VDD pch w=0.52u l=0.06u
MI1_0 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_1 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_2 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_3 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_4 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_5 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_6 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI1_7 net038 A2 ZN VDD pch w=0.52u l=0.06u
MI19-MI12 net038 B XI19-net11 VDD pch w=4.16u l=0.06u
MI19-MI13 XI19-net11 C VDD VDD pch w=4.16u l=0.06u
.ends
.subckt AOI21D0 A1 A2 B ZN VDD VSS
MI2 ZN A1 net27 VSS nch w=0.195u l=0.06u
MI10 net27 A2 VSS VSS nch w=0.195u l=0.06u
MI11 ZN B VSS VSS nch w=0.195u l=0.06u
MI8 ZN A2 net13 VDD pch w=0.26u l=0.06u
M_u2 net13 B VDD VDD pch w=0.26u l=0.06u
MI9 ZN A1 net13 VDD pch w=0.26u l=0.06u
.ends
.subckt AOI21D1 A1 A2 B ZN VDD VSS
MI2 ZN A1 net27 VSS nch w=0.39u l=0.06u
MI3 net27 A2 VSS VSS nch w=0.39u l=0.06u
M_u7 ZN B VSS VSS nch w=0.39u l=0.06u
M_u4 net13 A2 ZN VDD pch w=0.52u l=0.06u
M_u2 net13 B VDD VDD pch w=0.52u l=0.06u
M_u3 net13 A1 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt AOI21D2 A1 A2 B ZN VDD VSS
MI20 net024 A2 VSS VSS nch w=0.39u l=0.06u
MI19 ZN A1 net024 VSS nch w=0.39u l=0.06u
MI2 ZN A1 net026 VSS nch w=0.39u l=0.06u
MI12 net026 A2 VSS VSS nch w=0.39u l=0.06u
MI11_0 ZN B VSS VSS nch w=0.39u l=0.06u
MI11_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI15 ZN A2 net74 VDD pch w=1.04u l=0.06u
M_u2 net74 B VDD VDD pch w=1.04u l=0.06u
MI16 ZN A1 net74 VDD pch w=1.04u l=0.06u
.ends
.subckt AOI21D4 A1 A2 B ZN VDD VSS
MI2 ZN A1 net030 VSS nch w=1.56u l=0.06u
MI19_0 ZN B VSS VSS nch w=0.39u l=0.06u
MI19_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI19_2 ZN B VSS VSS nch w=0.39u l=0.06u
MI19_3 ZN B VSS VSS nch w=0.39u l=0.06u
MI18 net030 A2 VSS VSS nch w=1.56u l=0.06u
MI22 ZN A2 net034 VDD pch w=2.08u l=0.06u
M_u2 net034 B VDD VDD pch w=2.08u l=0.06u
MI23 ZN A1 net034 VDD pch w=2.08u l=0.06u
.ends
.subckt AOI221D0 A1 A2 B1 B2 C ZN VDD VSS
MI17-M_u10 ZN B1 XI17-net17 VSS nch w=0.195u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.195u l=0.06u
MI10-M_u10 ZN A1 XI10-net17 VSS nch w=0.195u l=0.06u
MI10-M_u11 XI10-net17 A2 VSS VSS nch w=0.195u l=0.06u
MU20 ZN C VSS VSS nch w=0.195u l=0.06u
MI9 net30 A1 ZN VDD pch w=0.28u l=0.06u
MI8 net30 A2 ZN VDD pch w=0.28u l=0.06u
MU22 VDD C net36 VDD pch w=0.26u l=0.06u
MI6 net36 B2 net30 VDD pch w=0.26u l=0.06u
MI7 net36 B1 net30 VDD pch w=0.26u l=0.06u
.ends
.subckt AOI221D1 A1 A2 B1 B2 C ZN VDD VSS
M_u5 net36 B2 net30 VDD pch w=0.52u l=0.06u
MU22 VDD C net36 VDD pch w=0.52u l=0.06u
M_u2 net30 A1 ZN VDD pch w=0.52u l=0.06u
M_u3 net30 A2 ZN VDD pch w=0.52u l=0.06u
M_u4 net36 B1 net30 VDD pch w=0.52u l=0.06u
MU20 ZN C VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 ZN B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u10 ZN A1 XI1-net17 VSS nch w=0.39u l=0.06u
MI1-M_u11 XI1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI221D2 A1 A2 B1 B2 C ZN VDD VSS
MI12 net27 A1 ZN VDD pch w=1.04u l=0.06u
MI9 net33 B2 net27 VDD pch w=1.04u l=0.06u
MU22 VDD C net33 VDD pch w=1.04u l=0.06u
MI11 net27 A2 ZN VDD pch w=1.04u l=0.06u
MI10 net33 B1 net27 VDD pch w=1.04u l=0.06u
MU20_0 ZN C VSS VSS nch w=0.39u l=0.06u
MU20_1 ZN C VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u10 ZN B1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 ZN B1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI8_0-M_u10 ZN A1 XI8_0-net17 VSS nch w=0.39u l=0.06u
MI8_0-M_u11 XI8_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u10 ZN A1 XI8_1-net17 VSS nch w=0.39u l=0.06u
MI8_1-M_u11 XI8_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI221D4 A1 A2 B1 B2 C ZN VDD VSS
MI6-M_u3 ZN net24 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net24 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net24 net45 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 ZN net24 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net24 VDD VDD pch w=0.52u l=0.06u
M_u5 net36 B2 net30 VDD pch w=0.52u l=0.06u
MU22 VDD C net36 VDD pch w=0.52u l=0.06u
M_u2 net30 A1 net45 VDD pch w=0.52u l=0.06u
M_u3 net30 A2 net45 VDD pch w=0.52u l=0.06u
M_u4 net36 B1 net30 VDD pch w=0.52u l=0.06u
MI6-M_u2 ZN net24 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net24 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net24 net45 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 ZN net24 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net24 VSS VSS nch w=0.39u l=0.06u
MU20 net45 C VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 net45 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u10 net45 A1 XI1-net17 VSS nch w=0.39u l=0.06u
MI1-M_u11 XI1-net17 A2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI221XD4 A1 A2 B1 B2 C ZN VDD VSS
MI15-M_u10 ZN B1 XI15-net17 VSS nch w=1.56u l=0.06u
MI15-M_u11 XI15-net17 B2 VSS VSS nch w=1.56u l=0.06u
MI16-M_u10 ZN A1 XI16-net17 VSS nch w=1.56u l=0.06u
MI16-M_u11 XI16-net17 A2 VSS VSS nch w=1.56u l=0.06u
MU20_0 ZN C VSS VSS nch w=0.39u l=0.06u
MU20_1 ZN C VSS VSS nch w=0.39u l=0.06u
MU20_2 ZN C VSS VSS nch w=0.39u l=0.06u
MU20_3 ZN C VSS VSS nch w=0.39u l=0.06u
MI17 net041 B2 net035 VDD pch w=2.08u l=0.06u
MI18 net041 B1 net035 VDD pch w=2.08u l=0.06u
MI19 net035 A2 ZN VDD pch w=2.08u l=0.06u
MI20 net035 A1 ZN VDD pch w=2.08u l=0.06u
MU22 VDD C net041 VDD pch w=2.08u l=0.06u
.ends
.subckt AOI222D0 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI21-M_u10 ZN C1 XI21-net17 VSS nch w=0.195u l=0.06u
MI21-M_u11 XI21-net17 C2 VSS VSS nch w=0.195u l=0.06u
MI6-M_u10 ZN A1 XI6-net17 VSS nch w=0.195u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.195u l=0.06u
MI20-M_u10 ZN B1 XI20-net17 VSS nch w=0.195u l=0.06u
MI20-M_u11 XI20-net17 B2 VSS VSS nch w=0.195u l=0.06u
MI15 VDD C1 net22 VDD pch w=0.26u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.26u l=0.06u
MI19 net16 A1 ZN VDD pch w=0.26u l=0.06u
MI18 net16 A2 ZN VDD pch w=0.26u l=0.06u
MI17 net22 B1 net16 VDD pch w=0.26u l=0.06u
MI16 net22 B2 net16 VDD pch w=0.26u l=0.06u
.ends
.subckt AOI222D1 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MU22 VDD C1 net22 VDD pch w=0.52u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.52u l=0.06u
M_u2 net16 A1 ZN VDD pch w=0.52u l=0.06u
M_u3 net16 A2 ZN VDD pch w=0.52u l=0.06u
M_u4 net22 B1 net16 VDD pch w=0.52u l=0.06u
M_u5 net22 B2 net16 VDD pch w=0.52u l=0.06u
MI17-M_u10 ZN C1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6-M_u10 ZN A1 XI6-net17 VSS nch w=0.39u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI7-M_u10 ZN B1 XI7-net17 VSS nch w=0.39u l=0.06u
MI7-M_u11 XI7-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI222D2 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI26 VDD C1 net35 VDD pch w=1.04u l=0.06u
MU27 VDD C2 net35 VDD pch w=1.04u l=0.06u
MI30 net29 A1 ZN VDD pch w=1.04u l=0.06u
MI29 net29 A2 ZN VDD pch w=1.04u l=0.06u
MI28 net35 B1 net29 VDD pch w=1.04u l=0.06u
MI27 net35 B2 net29 VDD pch w=1.04u l=0.06u
MI21_0-M_u10 ZN C1 XI21_0-net17 VSS nch w=0.39u l=0.06u
MI21_0-M_u11 XI21_0-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI21_1-M_u10 ZN C1 XI21_1-net17 VSS nch w=0.39u l=0.06u
MI21_1-M_u11 XI21_1-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6_0-M_u10 ZN A1 XI6_0-net17 VSS nch w=0.39u l=0.06u
MI6_0-M_u11 XI6_0-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI6_1-M_u10 ZN A1 XI6_1-net17 VSS nch w=0.39u l=0.06u
MI6_1-M_u11 XI6_1-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u10 ZN B1 XI20_0-net17 VSS nch w=0.39u l=0.06u
MI20_0-M_u11 XI20_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u10 ZN B1 XI20_1-net17 VSS nch w=0.39u l=0.06u
MI20_1-M_u11 XI20_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI222D4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI8-M_u3 ZN net29 VDD VDD pch w=0.52u l=0.06u
MI9-M_u3 ZN net29 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net29 net47 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 ZN net29 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net29 VDD VDD pch w=0.52u l=0.06u
MU22 VDD C1 net22 VDD pch w=0.52u l=0.06u
MU27 VDD C2 net22 VDD pch w=0.52u l=0.06u
M_u2 net16 A1 net47 VDD pch w=0.52u l=0.06u
M_u3 net16 A2 net47 VDD pch w=0.52u l=0.06u
M_u4 net22 B1 net16 VDD pch w=0.52u l=0.06u
M_u5 net22 B2 net16 VDD pch w=0.52u l=0.06u
MI8-M_u2 ZN net29 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 ZN net29 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net29 net47 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 ZN net29 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net29 VSS VSS nch w=0.39u l=0.06u
MI17-M_u10 net47 C1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 C2 VSS VSS nch w=0.39u l=0.06u
MI6-M_u10 net47 A1 XI6-net17 VSS nch w=0.39u l=0.06u
MI6-M_u11 XI6-net17 A2 VSS VSS nch w=0.39u l=0.06u
MI7-M_u10 net47 B1 XI7-net17 VSS nch w=0.39u l=0.06u
MI7-M_u11 XI7-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI222XD4 A1 A2 B1 B2 C1 C2 ZN VDD VSS
MI22 net044 A1 ZN VDD pch w=2.08u l=0.06u
MI28 net038 B1 net044 VDD pch w=2.08u l=0.06u
MI27 net044 A2 ZN VDD pch w=2.08u l=0.06u
MI31 VDD C2 net038 VDD pch w=2.08u l=0.06u
MI30 VDD C1 net038 VDD pch w=2.08u l=0.06u
MI29 net038 B2 net044 VDD pch w=2.08u l=0.06u
MI25-M_u10 ZN B1 XI25-net17 VSS nch w=1.56u l=0.06u
MI25-M_u11 XI25-net17 B2 VSS VSS nch w=1.56u l=0.06u
MI26-M_u10 ZN A1 XI26-net17 VSS nch w=1.56u l=0.06u
MI26-M_u11 XI26-net17 A2 VSS VSS nch w=1.56u l=0.06u
MI24-M_u10 ZN C1 XI24-net17 VSS nch w=1.56u l=0.06u
MI24-M_u11 XI24-net17 C2 VSS VSS nch w=1.56u l=0.06u
.ends
.subckt AOI22D0 A1 A2 B1 B2 ZN VDD VSS
MI22 net29 B2 VSS VSS nch w=0.195u l=0.06u
MI21 ZN B1 net29 VSS nch w=0.195u l=0.06u
MI9 ZN A1 net23 VSS nch w=0.195u l=0.06u
MI20 net23 A2 VSS VSS nch w=0.195u l=0.06u
MI18 net20 A2 ZN VDD pch w=0.26u l=0.06u
MI19 net20 A1 ZN VDD pch w=0.26u l=0.06u
MI17 VDD B1 net20 VDD pch w=0.26u l=0.06u
M_u5 VDD B2 net20 VDD pch w=0.26u l=0.06u
.ends
.subckt AOI22D1 A1 A2 B1 B2 ZN VDD VSS
MI3 ZN B1 net29 VSS nch w=0.39u l=0.06u
MI8 net29 B2 VSS VSS nch w=0.39u l=0.06u
MI9 ZN A1 net23 VSS nch w=0.39u l=0.06u
MI10 net23 A2 VSS VSS nch w=0.39u l=0.06u
M_u2 net20 A1 ZN VDD pch w=0.52u l=0.06u
M_u4 VDD B1 net20 VDD pch w=0.52u l=0.06u
M_u3 net20 A2 ZN VDD pch w=0.52u l=0.06u
M_u5 VDD B2 net20 VDD pch w=0.52u l=0.06u
.ends
.subckt AOI22D2 A1 A2 B1 B2 ZN VDD VSS
MI16_0 ZN B1 net031<0> VSS nch w=0.39u l=0.06u
MI16_1 ZN B1 net031<1> VSS nch w=0.39u l=0.06u
MI15_0 net031<0> B2 VSS VSS nch w=0.39u l=0.06u
MI15_1 net031<1> B2 VSS VSS nch w=0.39u l=0.06u
MI20_0 net034<0> A2 VSS VSS nch w=0.39u l=0.06u
MI20_1 net034<1> A2 VSS VSS nch w=0.39u l=0.06u
MI19_0 ZN A1 net034<0> VSS nch w=0.39u l=0.06u
MI19_1 ZN A1 net034<1> VSS nch w=0.39u l=0.06u
MI25 net20 A1 ZN VDD pch w=1.04u l=0.06u
MI24 net20 A2 ZN VDD pch w=1.04u l=0.06u
MI23 VDD B1 net20 VDD pch w=1.04u l=0.06u
MI11 VDD B2 net20 VDD pch w=1.04u l=0.06u
.ends
.subckt AOI22D4 A1 A2 B1 B2 ZN VDD VSS
MI34 net023 B2 VSS VSS nch w=1.56u l=0.06u
MI33 ZN B1 net023 VSS nch w=1.56u l=0.06u
MI32 net029 A2 VSS VSS nch w=1.56u l=0.06u
MI27 ZN A1 net029 VSS nch w=1.56u l=0.06u
MI31 net034 A1 ZN VDD pch w=2.08u l=0.06u
MI30 net034 A2 ZN VDD pch w=2.08u l=0.06u
MI29 VDD B1 net034 VDD pch w=2.08u l=0.06u
M_u5 VDD B2 net034 VDD pch w=2.08u l=0.06u
.ends
.subckt AOI31D0 A1 A2 A3 B ZN VDD VSS
MI6 ZN A1 net19 VDD pch w=0.26u l=0.06u
MI4 ZN A3 net19 VDD pch w=0.26u l=0.06u
MI5 ZN A2 net19 VDD pch w=0.26u l=0.06u
MU20 net19 B VDD VDD pch w=0.26u l=0.06u
MU14 ZN B VSS VSS nch w=0.195u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=0.195u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.195u l=0.06u
.ends
.subckt AOI31D1 A1 A2 A3 B ZN VDD VSS
MU17 ZN A1 net19 VDD pch w=0.52u l=0.06u
MU18 ZN A3 net19 VDD pch w=0.52u l=0.06u
MU16 ZN A2 net19 VDD pch w=0.52u l=0.06u
MU20 net19 B VDD VDD pch w=0.52u l=0.06u
MU14 ZN B VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI31D2 A1 A2 A3 B ZN VDD VSS
MI8 ZN A2 net19 VDD pch w=1.04u l=0.06u
MI9 ZN A1 net19 VDD pch w=1.04u l=0.06u
MI7 ZN A3 net19 VDD pch w=1.04u l=0.06u
MU20 net19 B VDD VDD pch w=1.04u l=0.06u
MU14 ZN B VSS VSS nch w=0.78u l=0.06u
MI20_0-MI12 XI20_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u10 ZN A1 XI20_0-net17 VSS nch w=0.39u l=0.06u
MI20_0-M_u11 XI20_0-net17 A2 XI20_0-net13 VSS nch w=0.39u l=0.06u
MI20_1-MI12 XI20_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u10 ZN A1 XI20_1-net17 VSS nch w=0.39u l=0.06u
MI20_1-M_u11 XI20_1-net17 A2 XI20_1-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI31D4 A1 A2 A3 B ZN VDD VSS
MI11 ZN A1 net026 VDD pch w=2.08u l=0.06u
MI10 ZN A2 net026 VDD pch w=2.08u l=0.06u
MI9 ZN A3 net026 VDD pch w=2.08u l=0.06u
MU20 net026 B VDD VDD pch w=2.08u l=0.06u
MU14_0 ZN B VSS VSS nch w=0.39u l=0.06u
MU14_1 ZN B VSS VSS nch w=0.39u l=0.06u
MU14_2 ZN B VSS VSS nch w=0.39u l=0.06u
MU14_3 ZN B VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=1.56u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=1.56u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=1.56u l=0.06u
.ends
.subckt AOI32D0 A1 A2 A3 B1 B2 ZN VDD VSS
MI8 ZN A1 net23 VDD pch w=0.26u l=0.06u
MI6 ZN A3 net23 VDD pch w=0.26u l=0.06u
MI7 ZN A2 net23 VDD pch w=0.26u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.26u l=0.06u
MI5 net23 B2 VDD VDD pch w=0.26u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=0.195u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.195u l=0.06u
MI17-M_u10 ZN B1 XI17-net17 VSS nch w=0.195u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.195u l=0.06u
.ends
.subckt AOI32D1 A1 A2 A3 B1 B2 ZN VDD VSS
MU17 ZN A1 net23 VDD pch w=0.52u l=0.06u
MU18 ZN A3 net23 VDD pch w=0.52u l=0.06u
MU16 ZN A2 net23 VDD pch w=0.52u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.52u l=0.06u
MU19 net23 B2 VDD VDD pch w=0.52u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
MI17-M_u10 ZN B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI32D2 A1 A2 A3 B1 B2 ZN VDD VSS
MI9 net23 B2 VDD VDD pch w=1.04u l=0.06u
MI10 ZN A3 net23 VDD pch w=1.04u l=0.06u
MI11 ZN A2 net23 VDD pch w=1.04u l=0.06u
MI12 ZN A1 net23 VDD pch w=1.04u l=0.06u
MU20 net23 B1 VDD VDD pch w=1.04u l=0.06u
MI20_0-MI12 XI20_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_0-M_u10 ZN A1 XI20_0-net17 VSS nch w=0.39u l=0.06u
MI20_0-M_u11 XI20_0-net17 A2 XI20_0-net13 VSS nch w=0.39u l=0.06u
MI20_1-MI12 XI20_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20_1-M_u10 ZN A1 XI20_1-net17 VSS nch w=0.39u l=0.06u
MI20_1-M_u11 XI20_1-net17 A2 XI20_1-net13 VSS nch w=0.39u l=0.06u
MI17_0-M_u10 ZN B1 XI17_0-net17 VSS nch w=0.39u l=0.06u
MI17_0-M_u11 XI17_0-net17 B2 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u10 ZN B1 XI17_1-net17 VSS nch w=0.39u l=0.06u
MI17_1-M_u11 XI17_1-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI32D4 A1 A2 A3 B1 B2 ZN VDD VSS
MI6-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net25 net35 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net25 VDD VDD pch w=0.52u l=0.06u
MU17 net35 A1 net23 VDD pch w=0.52u l=0.06u
MU18 net35 A3 net23 VDD pch w=0.52u l=0.06u
MU16 net35 A2 net23 VDD pch w=0.52u l=0.06u
MU20 net23 B1 VDD VDD pch w=0.52u l=0.06u
MU19 net23 B2 VDD VDD pch w=0.52u l=0.06u
MI6-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net25 net35 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net25 VSS VSS nch w=0.39u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI20-M_u10 net35 A1 XI20-net17 VSS nch w=0.39u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=0.39u l=0.06u
MI17-M_u10 net35 B1 XI17-net17 VSS nch w=0.39u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt AOI32XD4 A1 A2 A3 B1 B2 ZN VDD VSS
MI12 net039 B1 VDD VDD pch w=2.08u l=0.06u
MI8 ZN A1 net039 VDD pch w=2.08u l=0.06u
MI10 ZN A3 net039 VDD pch w=2.08u l=0.06u
MI9 ZN A2 net039 VDD pch w=2.08u l=0.06u
MI11 net039 B2 VDD VDD pch w=2.08u l=0.06u
MI20-MI12 XI20-net13 A3 VSS VSS nch w=1.56u l=0.06u
MI20-M_u10 ZN A1 XI20-net17 VSS nch w=1.56u l=0.06u
MI20-M_u11 XI20-net17 A2 XI20-net13 VSS nch w=1.56u l=0.06u
MI17-M_u10 ZN B1 XI17-net17 VSS nch w=1.56u l=0.06u
MI17-M_u11 XI17-net17 B2 VSS VSS nch w=1.56u l=0.06u
.ends
.subckt AOI33D0 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI11 net40 A2 ZN VDD pch w=0.28u l=0.06u
MI12 net40 A1 ZN VDD pch w=0.28u l=0.06u
M_u16 VDD B3 net40 VDD pch w=0.26u l=0.06u
MI9 VDD B1 net40 VDD pch w=0.26u l=0.06u
MI10 net40 A3 ZN VDD pch w=0.28u l=0.06u
MI8 VDD B2 net40 VDD pch w=0.26u l=0.06u
MI13-MI12 XI13-net13 A3 VSS VSS nch w=0.195u l=0.06u
MI13-M_u10 ZN A1 XI13-net17 VSS nch w=0.195u l=0.06u
MI13-M_u11 XI13-net17 A2 XI13-net13 VSS nch w=0.195u l=0.06u
MI7-MI12 XI7-net13 B3 VSS VSS nch w=0.195u l=0.06u
MI7-M_u10 ZN B1 XI7-net17 VSS nch w=0.195u l=0.06u
MI7-M_u11 XI7-net17 B2 XI7-net13 VSS nch w=0.195u l=0.06u
.ends
.subckt AOI33D1 A1 A2 A3 B1 B2 B3 ZN VDD VSS
M_u16 VDD B3 net40 VDD pch w=0.52u l=0.06u
M_u15 VDD B2 net40 VDD pch w=0.52u l=0.06u
M_u13 net40 A3 ZN VDD pch w=0.52u l=0.06u
M_u12 net40 A2 ZN VDD pch w=0.52u l=0.06u
M_u11 net40 A1 ZN VDD pch w=0.52u l=0.06u
M_u14 VDD B1 net40 VDD pch w=0.52u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 ZN A1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=0.39u l=0.06u
MI2-MI12 XI2-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI2-M_u10 ZN B1 XI2-net17 VSS nch w=0.39u l=0.06u
MI2-M_u11 XI2-net17 B2 XI2-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI33D2 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI13 net40 A2 ZN VDD pch w=1.04u l=0.06u
MI14 net40 A1 ZN VDD pch w=1.04u l=0.06u
M_u16 VDD B3 net40 VDD pch w=1.04u l=0.06u
MI11 VDD B1 net40 VDD pch w=1.04u l=0.06u
MI12 net40 A3 ZN VDD pch w=1.04u l=0.06u
MI10 VDD B2 net40 VDD pch w=1.04u l=0.06u
MI15_0-MI12 XI15_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI15_0-M_u10 ZN A1 XI15_0-net17 VSS nch w=0.39u l=0.06u
MI15_0-M_u11 XI15_0-net17 A2 XI15_0-net13 VSS nch w=0.39u l=0.06u
MI15_1-MI12 XI15_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u10 ZN A1 XI15_1-net17 VSS nch w=0.39u l=0.06u
MI15_1-M_u11 XI15_1-net17 A2 XI15_1-net13 VSS nch w=0.39u l=0.06u
MI2_0-MI12 XI2_0-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u10 ZN B1 XI2_0-net17 VSS nch w=0.39u l=0.06u
MI2_0-M_u11 XI2_0-net17 B2 XI2_0-net13 VSS nch w=0.39u l=0.06u
MI2_1-MI12 XI2_1-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u10 ZN B1 XI2_1-net17 VSS nch w=0.39u l=0.06u
MI2_1-M_u11 XI2_1-net17 B2 XI2_1-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI33D4 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI6-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net26 net50 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net26 VDD VDD pch w=0.52u l=0.06u
M_u16 VDD B3 net40 VDD pch w=0.52u l=0.06u
M_u15 VDD B2 net40 VDD pch w=0.52u l=0.06u
M_u13 net40 A3 net50 VDD pch w=0.52u l=0.06u
M_u12 net40 A2 net50 VDD pch w=0.52u l=0.06u
M_u11 net40 A1 net50 VDD pch w=0.52u l=0.06u
M_u14 VDD B1 net40 VDD pch w=0.52u l=0.06u
MI6-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net26 net50 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net26 VSS VSS nch w=0.39u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI14-M_u10 net50 A1 XI14-net17 VSS nch w=0.39u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=0.39u l=0.06u
MI2-MI12 XI2-net13 B3 VSS VSS nch w=0.39u l=0.06u
MI2-M_u10 net50 B1 XI2-net17 VSS nch w=0.39u l=0.06u
MI2-M_u11 XI2-net17 B2 XI2-net13 VSS nch w=0.39u l=0.06u
.ends
.subckt AOI33XD4 A1 A2 A3 B1 B2 B3 ZN VDD VSS
MI13 net041 A1 ZN VDD pch w=2.08u l=0.06u
MI18 VDD B2 net041 VDD pch w=2.08u l=0.06u
MI19 VDD B3 net041 VDD pch w=2.08u l=0.06u
MI17 VDD B1 net041 VDD pch w=2.08u l=0.06u
MI16 net041 A3 ZN VDD pch w=2.08u l=0.06u
MI15 net041 A2 ZN VDD pch w=2.08u l=0.06u
MI14-MI12 XI14-net13 A3 VSS VSS nch w=1.56u l=0.06u
MI14-M_u10 ZN A1 XI14-net17 VSS nch w=1.56u l=0.06u
MI14-M_u11 XI14-net17 A2 XI14-net13 VSS nch w=1.56u l=0.06u
MI20-MI12 XI20-net13 B3 VSS VSS nch w=1.56u l=0.06u
MI20-M_u10 ZN B1 XI20-net17 VSS nch w=1.56u l=0.06u
MI20-M_u11 XI20-net17 B2 XI20-net13 VSS nch w=1.56u l=0.06u
.ends
.subckt BENCD1 M0 M1 M2 X2 A S VDD VSS
M_u6-M_u3 net58 M1 net29 VSS nch w=0.275u l=0.06u
MI111 net57 net58 VSS VSS nch w=0.39u l=0.06u
MI5 net29 net98 net57 VSS nch w=0.19u l=0.06u
MI42 A M1 net61 VSS nch w=0.39u l=0.06u
MI43 A M0 net61 VSS nch w=0.39u l=0.06u
MI44 net61 net89 VSS VSS nch w=0.365u l=0.06u
MI39 net105 M2 VSS VSS nch w=0.39u l=0.06u
M_u3 S net58 net105 VSS nch w=0.39u l=0.06u
MI38 S net98 net105 VSS nch w=0.39u l=0.06u
M_u2-M_u2 net58 M0 VSS VSS nch w=0.2u l=0.06u
M_u4-M_u2 X2 net29 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net98 M1 VSS VSS nch w=0.39u l=0.06u
MI47-M_u2 net89 M2 VSS VSS nch w=0.39u l=0.06u
MI40-MI12 A M1 XI40-net11 VDD pch w=0.52u l=0.06u
MI40-MI13 XI40-net11 M0 VDD VDD pch w=0.52u l=0.06u
MI16-MI12 S net98 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 net58 VDD VDD pch w=0.52u l=0.06u
M_u6-M_u2 net58 net98 net29 VDD pch w=0.22u l=0.06u
MI45 A net89 VDD VDD pch w=0.52u l=0.06u
M_u9 S M2 VDD VDD pch w=0.52u l=0.06u
MI4 net62 M1 net29 VDD pch w=0.235u l=0.06u
MI2 VDD net58 net62 VDD pch w=0.52u l=0.06u
M_u2-M_u3 net58 M0 VDD VDD pch w=0.32u l=0.06u
M_u4-M_u3 X2 net29 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net98 M1 VDD VDD pch w=0.52u l=0.06u
MI47-M_u3 net89 M2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BENCD2 M0 M1 M2 X2 A S VDD VSS
M_u6-M_u3 net96 M1 net29 VSS nch w=0.26u l=0.06u
MI59 net155 M2 VSS VSS nch w=0.78u l=0.06u
MI64 A M0 net146 VSS nch w=0.78u l=0.06u
MI111 net65 net96 VSS VSS nch w=0.26u l=0.06u
MI5 net29 net102 net65 VSS nch w=0.26u l=0.06u
MI65 A M1 net146 VSS nch w=0.78u l=0.06u
MI66 net146 net104 VSS VSS nch w=0.78u l=0.06u
M_u3 S net96 net155 VSS nch w=0.78u l=0.06u
MI58 S net102 net155 VSS nch w=0.78u l=0.06u
M_u2-M_u2 net96 M0 VSS VSS nch w=0.2u l=0.06u
M_u4_0-M_u2 X2 net29 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 X2 net29 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net102 M1 VSS VSS nch w=0.2u l=0.06u
MI47-M_u2 net104 M2 VSS VSS nch w=0.39u l=0.06u
MI16-MI12 S net102 XI16-net11 VDD pch w=1.04u l=0.06u
MI16-MI13 XI16-net11 net96 VDD VDD pch w=1.04u l=0.06u
M_u6-M_u2 net96 net102 net29 VDD pch w=0.26u l=0.06u
MI63 A M1 net77 VDD pch w=0.8u l=0.06u
MI4 net58 M1 net29 VDD pch w=0.26u l=0.06u
MI2 VDD net96 net58 VDD pch w=0.26u l=0.06u
MI61 A net104 VDD VDD pch w=1.04u l=0.06u
MI62 net77 M0 VDD VDD pch w=1.04u l=0.06u
M_u9 S M2 VDD VDD pch w=1.04u l=0.06u
M_u2-M_u3 net96 M0 VDD VDD pch w=0.34u l=0.06u
M_u4_0-M_u3 X2 net29 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 X2 net29 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net102 M1 VDD VDD pch w=0.26u l=0.06u
MI47-M_u3 net104 M2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BENCD4 M0 M1 M2 X2 A S VDD VSS
MI60-M_u3 net63 M1 net62 VSS nch w=0.29u l=0.06u
MI91 net068 net63 VSS VSS nch w=0.39u l=0.06u
MI89 net62 net107 net068 VSS nch w=0.41u l=0.06u
MI81 A M1 net081 VSS nch w=1.56u l=0.06u
MI82 net081 p0 VSS VSS nch w=1.56u l=0.06u
MI80 A M0 net081 VSS nch w=1.56u l=0.06u
MI84 S net107 net072 VSS nch w=1.56u l=0.06u
MI83 S net63 net072 VSS nch w=1.56u l=0.06u
MI85 net072 M2 VSS VSS nch w=1.56u l=0.06u
MI58_0-M_u2 net63 M0 VSS VSS nch w=0.21u l=0.06u
MI58_1-M_u2 net63 M0 VSS VSS nch w=0.21u l=0.06u
M_u4_0-M_u2 X2 net62 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 X2 net62 VSS VSS nch w=0.39u l=0.06u
M_u4_2-M_u2 X2 net62 VSS VSS nch w=0.39u l=0.06u
M_u4_3-M_u2 X2 net62 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net107 M1 VSS VSS nch w=0.26u l=0.06u
MI47_0-M_u2 p0 M2 VSS VSS nch w=0.39u l=0.06u
MI47_1-M_u2 p0 M2 VSS VSS nch w=0.39u l=0.06u
MI16-MI12 S net107 XI16-net11 VDD pch w=2.08u l=0.06u
MI16-MI13 XI16-net11 net63 VDD VDD pch w=2.08u l=0.06u
MI60-M_u2 net63 net107 net62 VDD pch w=0.34u l=0.06u
MI78 A M1 net089 VDD pch w=1.36u l=0.06u
MI90 net094 net63 VDD VDD pch w=0.32u l=0.06u
MI87 net62 M1 net094 VDD pch w=0.32u l=0.06u
MI77 net089 M0 VDD VDD pch w=2.08u l=0.06u
MI76_0 A p0 VDD VDD pch w=0.52u l=0.06u
MI76_1 A p0 VDD VDD pch w=0.52u l=0.06u
MI76_2 A p0 VDD VDD pch w=0.52u l=0.06u
MI76_3 A p0 VDD VDD pch w=0.52u l=0.06u
M_u9_0 S M2 VDD VDD pch w=0.52u l=0.06u
M_u9_1 S M2 VDD VDD pch w=0.52u l=0.06u
M_u9_2 S M2 VDD VDD pch w=0.52u l=0.06u
M_u9_3 S M2 VDD VDD pch w=0.52u l=0.06u
MI58_0-M_u3 net63 M0 VDD VDD pch w=0.32u l=0.06u
MI58_1-M_u3 net63 M0 VDD VDD pch w=0.32u l=0.06u
M_u4_0-M_u3 X2 net62 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 X2 net62 VDD VDD pch w=0.52u l=0.06u
M_u4_2-M_u3 X2 net62 VDD VDD pch w=0.52u l=0.06u
M_u4_3-M_u3 X2 net62 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net107 M1 VDD VDD pch w=0.5u l=0.06u
MI47_0-M_u3 p0 M2 VDD VDD pch w=0.52u l=0.06u
MI47_1-M_u3 p0 M2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BHD Z VDD VSS
M_u3 net8 Z VSS VSS nch w=0.39u l=0.06u
MU11 Z net8 VSS VSS nch w=0.15u l=0.08u
M_u7 net8 Z VDD VDD pch w=0.52u l=0.06u
MU12 Z net8 VDD VDD pch w=0.15u l=0.08u
.ends
.subckt BMLD1 X2 A S M0 M1 PP VDD VSS
MI53-M_u2 net123 net97 VSS VSS nch w=0.35u l=0.06u
MI66-M_u2 net111 X2 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net117 M0 VSS VSS nch w=0.35u l=0.06u
MI50-M_u2 net121 S VSS VSS nch w=0.35u l=0.06u
MI49-M_u2 net119 A VSS VSS nch w=0.35u l=0.06u
MI67-M_u2 net115 M1 VSS VSS nch w=0.35u l=0.06u
MI37-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 net125 net109 VSS VSS nch w=0.35u l=0.06u
MI62-M_u3 net97 M1 net119 VSS nch w=0.29u l=0.06u
MI64-M_u3 net58 net111 net123 VSS nch w=0.17u l=0.06u
MI63-M_u3 net97 net115 net121 VSS nch w=0.35u l=0.06u
MI60-M_u3 net109 M0 net119 VSS nch w=0.29u l=0.06u
MI61-M_u3 net109 net117 net121 VSS nch w=0.19u l=0.06u
MI65-M_u3 net58 X2 net125 VSS nch w=0.29u l=0.06u
MI53-M_u3 net123 net97 VDD VDD pch w=0.52u l=0.06u
MI66-M_u3 net111 X2 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net117 M0 VDD VDD pch w=0.51u l=0.06u
MI50-M_u3 net121 S VDD VDD pch w=0.51u l=0.06u
MI49-M_u3 net119 A VDD VDD pch w=0.51u l=0.06u
MI67-M_u3 net115 M1 VDD VDD pch w=0.52u l=0.06u
MI37-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 net125 net109 VDD VDD pch w=0.51u l=0.06u
MI62-M_u2 net97 net115 net119 VDD pch w=0.35u l=0.06u
MI64-M_u2 net58 X2 net123 VDD pch w=0.35u l=0.06u
MI63-M_u2 net97 M1 net121 VDD pch w=0.31u l=0.06u
MI60-M_u2 net109 net117 net119 VDD pch w=0.51u l=0.06u
MI61-M_u2 net109 M0 net121 VDD pch w=0.35u l=0.06u
MI65-M_u2 net58 net111 net125 VDD pch w=0.51u l=0.06u
.ends
.subckt BMLD2 X2 A S M0 M1 PP VDD VSS
MI53-M_u2 net123 net97 VSS VSS nch w=0.35u l=0.06u
MI56-M_u2 net117 M0 VSS VSS nch w=0.35u l=0.06u
MI58-M_u2 net111 X2 VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 net121 S VSS VSS nch w=0.35u l=0.06u
MI49-M_u2 net119 A VSS VSS nch w=0.35u l=0.06u
MI59-M_u2 net115 M1 VSS VSS nch w=0.35u l=0.06u
MI37_0-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI37_1-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 net125 net109 VSS VSS nch w=0.35u l=0.06u
MI62-M_u3 net97 M1 net119 VSS nch w=0.29u l=0.06u
MI64-M_u3 net58 net111 net123 VSS nch w=0.17u l=0.06u
MI63-M_u3 net97 net115 net121 VSS nch w=0.35u l=0.06u
MI60-M_u3 net109 M0 net119 VSS nch w=0.29u l=0.06u
MI61-M_u3 net109 net117 net121 VSS nch w=0.19u l=0.06u
MI65-M_u3 net58 X2 net125 VSS nch w=0.29u l=0.06u
MI53-M_u3 net123 net97 VDD VDD pch w=0.52u l=0.06u
MI56-M_u3 net117 M0 VDD VDD pch w=0.51u l=0.06u
MI58-M_u3 net111 X2 VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 net121 S VDD VDD pch w=0.51u l=0.06u
MI49-M_u3 net119 A VDD VDD pch w=0.51u l=0.06u
MI59-M_u3 net115 M1 VDD VDD pch w=0.52u l=0.06u
MI37_0-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI37_1-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 net125 net109 VDD VDD pch w=0.51u l=0.06u
MI62-M_u2 net97 net115 net119 VDD pch w=0.35u l=0.06u
MI64-M_u2 net58 X2 net123 VDD pch w=0.35u l=0.06u
MI63-M_u2 net97 M1 net121 VDD pch w=0.31u l=0.06u
MI60-M_u2 net109 net117 net119 VDD pch w=0.51u l=0.06u
MI61-M_u2 net109 M0 net121 VDD pch w=0.35u l=0.06u
MI65-M_u2 net58 net111 net125 VDD pch w=0.51u l=0.06u
.ends
.subckt BMLD4 X2 A S M0 M1 PP VDD VSS
MI53_0-M_u2 net55 net60 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 net55 net60 VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 net117 M0 VSS VSS nch w=0.39u l=0.06u
MI79-M_u2 net111 X2 VSS VSS nch w=0.39u l=0.06u
MI70_0-M_u2 net121 S VSS VSS nch w=0.39u l=0.06u
MI70_1-M_u2 net121 S VSS VSS nch w=0.39u l=0.06u
MI49_0-M_u2 net119 A VSS VSS nch w=0.39u l=0.06u
MI49_1-M_u2 net119 A VSS VSS nch w=0.39u l=0.06u
MI77-M_u2 net115 M1 VSS VSS nch w=0.39u l=0.06u
MI37_0-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI37_1-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI37_2-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI37_3-M_u2 PP net58 VSS VSS nch w=0.39u l=0.06u
MI26_0-M_u2 net71 net109 VSS VSS nch w=0.39u l=0.06u
MI26_1-M_u2 net71 net109 VSS VSS nch w=0.39u l=0.06u
MI72-M_u3 net60 M1 net119 VSS nch w=0.29u l=0.06u
MI75-M_u3 net58 net111 net55 VSS nch w=0.21u l=0.06u
MI73-M_u3 net60 net115 net121 VSS nch w=0.39u l=0.06u
MI60-M_u3 net109 M0 net119 VSS nch w=0.29u l=0.06u
MI71-M_u3 net109 net117 net121 VSS nch w=0.23u l=0.06u
MI74-M_u3 net58 X2 net71 VSS nch w=0.29u l=0.06u
MI53_0-M_u3 net55 net60 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 net55 net60 VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 net117 M0 VDD VDD pch w=0.51u l=0.06u
MI79-M_u3 net111 X2 VDD VDD pch w=0.52u l=0.06u
MI70_0-M_u3 net121 S VDD VDD pch w=0.51u l=0.06u
MI70_1-M_u3 net121 S VDD VDD pch w=0.51u l=0.06u
MI49_0-M_u3 net119 A VDD VDD pch w=0.51u l=0.06u
MI49_1-M_u3 net119 A VDD VDD pch w=0.51u l=0.06u
MI77-M_u3 net115 M1 VDD VDD pch w=0.52u l=0.06u
MI37_0-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI37_1-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI37_2-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI37_3-M_u3 PP net58 VDD VDD pch w=0.52u l=0.06u
MI26_0-M_u3 net71 net109 VDD VDD pch w=0.51u l=0.06u
MI26_1-M_u3 net71 net109 VDD VDD pch w=0.51u l=0.06u
MI72-M_u2 net60 net115 net119 VDD pch w=0.35u l=0.06u
MI75-M_u2 net58 X2 net55 VDD pch w=0.35u l=0.06u
MI73-M_u2 net60 M1 net121 VDD pch w=0.31u l=0.06u
MI60-M_u2 net109 net117 net119 VDD pch w=0.51u l=0.06u
MI71-M_u2 net109 M0 net121 VDD pch w=0.35u l=0.06u
MI74-M_u2 net58 net111 net71 VDD pch w=0.51u l=0.06u
.ends
.subckt BUFFD0 I Z VDD VSS
MI1-M_u2 Z net6 VSS VSS nch w=0.195u l=0.06u
MI2-M_u2 net6 I VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 Z net6 VDD VDD pch w=0.26u l=0.06u
MI2-M_u3 net6 I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt BUFFD1 I Z VDD VSS
MI1-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net6 I VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net6 I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt BUFFD2 I Z VDD VSS
M_u2-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
M_u3_0-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD3 I Z VDD VSS
M_u3_0-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD4 I Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD6 I Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_4-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_5-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_4-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_5-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD8 I Z VDD VSS
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u7_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD12 I Z VDD VSS
MU8_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_8-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_9-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_10-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_11-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_3-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_8-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_9-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_10-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_11-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_3-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD16 I Z VDD VSS
MU8_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_8-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_9-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_10-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_11-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_12-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_13-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_14-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_15-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_3-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_4-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_8-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_9-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_10-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_11-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_12-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_13-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_14-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_15-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_3-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_4-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD20 I Z VDD VSS
MU8_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_8-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_9-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_10-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_11-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_12-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_13-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_14-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_15-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_16-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_17-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_18-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_19-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_3-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_4-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_5-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_8-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_9-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_10-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_11-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_12-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_13-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_14-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_15-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_16-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_17-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_18-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_19-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_3-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_4-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_5-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFFD24 I Z VDD VSS
MU8_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_8-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_9-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_10-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_11-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_12-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_13-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_14-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_15-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_16-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_17-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_18-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_19-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_20-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_21-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_22-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
MU8_23-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_3-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_4-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_5-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_6-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
MU8_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_8-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_9-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_10-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_11-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_12-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_13-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_14-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_15-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_16-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_17-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_18-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_19-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_20-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_21-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_22-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
MU8_23-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_3-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_4-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_5-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_6-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt BUFTD0 I OE Z VDD VSS
M_u17-M_u2 net31 OE VSS VSS nch w=0.195u l=0.06u
M_u7 Z INEN VSS VSS nch w=0.195u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.195u l=0.06u
MU19-M_u3 INEN net31 VSS VSS nch w=0.195u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.195u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.195u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.26u l=0.06u
MU19-M_u1 XU19-net8 net31 VDD VDD pch w=0.26u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.26u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.26u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.26u l=0.06u
M_u6 Z INEP VDD VDD pch w=0.26u l=0.06u
.ends
.subckt BUFTD1 I OE Z VDD VSS
M_u17-M_u2 net31 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=0.3u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MU19-M_u3 INEN net31 VSS VSS nch w=0.39u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.23u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.23u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
MU19-M_u1 XU19-net8 net31 VDD VDD pch w=0.52u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.52u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.23u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.23u l=0.06u
M_u6 Z INEP VDD VDD pch w=0.45u l=0.06u
.ends
.subckt BUFTD2 I OE Z VDD VSS
M_u17-M_u2 net31 OE VSS VSS nch w=0.335u l=0.06u
M_u7 Z INEN VSS VSS nch w=0.6u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.335u l=0.06u
MU19-M_u3 INEN net31 VSS VSS nch w=0.335u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.23u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.23u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
MU19-M_u1 XU19-net8 net31 VDD VDD pch w=0.46u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.46u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.23u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.23u l=0.06u
M_u6 Z INEP VDD VDD pch w=0.9u l=0.06u
.ends
.subckt BUFTD3 I OE Z VDD VSS
M_u17-M_u2 net31 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=0.94u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MU19-M_u3 INEN net31 VSS VSS nch w=0.39u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.23u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.23u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
MU19-M_u1 XU19-net8 net31 VDD VDD pch w=0.52u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.52u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.23u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.23u l=0.06u
M_u6 Z INEP VDD VDD pch w=1.39u l=0.06u
.ends
.subckt BUFTD4 I OE Z VDD VSS
M_u17-M_u2 net31 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=1.28u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MU19-M_u3 INEN net31 VSS VSS nch w=0.39u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.23u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.23u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
MU19-M_u1 XU19-net8 net31 VDD VDD pch w=0.52u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.52u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.23u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.23u l=0.06u
M_u6 Z INEP VDD VDD pch w=1.88u l=0.06u
.ends
.subckt BUFTD6 I OE Z VDD VSS
MI5_0-M_u4 INEN net13 VSS VSS nch w=0.39u l=0.06u
MI5_0-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u4 INEN net13 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
M_u17-M_u2 net13 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=1.96u l=0.06u
MI9-M_u4 XI9-net6 I VSS VSS nch w=0.39u l=0.06u
MI9-M_u3 INEP OE XI9-net6 VSS nch w=0.21u l=0.06u
MI7-M_u4 XI7-net6 I VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 INEP OE XI7-net6 VSS nch w=0.21u l=0.06u
MI5_0-M_u1 XI5_0-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_0-M_u2 INEN net13 XI5_0-net8 VDD pch w=0.34u l=0.06u
MI5_1-M_u1 XI5_1-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_1-M_u2 INEN net13 XI5_1-net8 VDD pch w=0.34u l=0.06u
M_u17-M_u3 net13 OE VDD VDD pch w=0.52u l=0.06u
MI9-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI9-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
MI7-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI7-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
M_u6 Z INEP VDD VDD pch w=2.86u l=0.06u
.ends
.subckt BUFTD8 I OE Z VDD VSS
MI5_0-M_u4 INEN net31 VSS VSS nch w=0.39u l=0.06u
MI5_0-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u4 INEN net31 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
M_u17-M_u2 net31 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=2.64u l=0.06u
MI6-M_u4 XI6-net6 I VSS VSS nch w=0.39u l=0.06u
MI6-M_u3 INEP OE XI6-net6 VSS nch w=0.21u l=0.06u
MI7-M_u4 XI7-net6 I VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 INEP OE XI7-net6 VSS nch w=0.21u l=0.06u
MI5_0-M_u1 XI5_0-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_0-M_u2 INEN net31 XI5_0-net8 VDD pch w=0.34u l=0.06u
MI5_1-M_u1 XI5_1-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_1-M_u2 INEN net31 XI5_1-net8 VDD pch w=0.34u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
MI6-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI6-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
MI7-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI7-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
M_u6 Z INEP VDD VDD pch w=3.84u l=0.06u
.ends
.subckt BUFTD12 I OE Z VDD VSS
M_u17-M_u2 net037 OE VSS VSS nch w=0.39u l=0.06u
MI10 INEP OE net027 VSS nch w=0.21u l=0.06u
MI13 net027 I VSS VSS nch w=0.39u l=0.06u
MI14 INEP OE net033 VSS nch w=0.21u l=0.06u
MI15 net033 I VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=4u l=0.06u
MI21 INEN net037 VSS VSS nch w=0.39u l=0.06u
MI22 INEN net037 VSS VSS nch w=0.39u l=0.06u
MI23 INEN I VSS VSS nch w=0.39u l=0.06u
MI24 INEN I VSS VSS nch w=0.39u l=0.06u
M_u17-M_u3 net037 OE VDD VDD pch w=0.52u l=0.06u
MI12 INEP I VDD VDD pch w=1.04u l=0.06u
MI7 INEP OE VDD VDD pch w=1.04u l=0.06u
M_u6 Z INEP VDD VDD pch w=5.8u l=0.06u
MI17 net062 I VDD VDD pch w=0.34u l=0.06u
MI18 net054 I VDD VDD pch w=0.34u l=0.06u
MI19 INEN net037 net054 VDD pch w=0.34u l=0.06u
MI20 INEN net037 net062 VDD pch w=0.34u l=0.06u
.ends
.subckt BUFTD16 I OE Z VDD VSS
MI5_0-M_u4 INEN net31 VSS VSS nch w=0.39u l=0.06u
MI5_0-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u4 INEN net31 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u3 INEN I VSS VSS nch w=0.39u l=0.06u
MI7-M_u4 XI7-net6 I VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 INEP OE XI7-net6 VSS nch w=0.21u l=0.06u
MI6-M_u4 XI6-net6 I VSS VSS nch w=0.39u l=0.06u
MI6-M_u3 INEP OE XI6-net6 VSS nch w=0.21u l=0.06u
M_u17-M_u2 net31 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z INEN VSS VSS nch w=5.36u l=0.06u
MI5_0-M_u1 XI5_0-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_0-M_u2 INEN net31 XI5_0-net8 VDD pch w=0.34u l=0.06u
MI5_1-M_u1 XI5_1-net8 I VDD VDD pch w=0.34u l=0.06u
MI5_1-M_u2 INEN net31 XI5_1-net8 VDD pch w=0.34u l=0.06u
MI7-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI7-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
MI6-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI6-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
M_u17-M_u3 net31 OE VDD VDD pch w=0.52u l=0.06u
M_u6 Z INEP VDD VDD pch w=7.76u l=0.06u
.ends
.subckt BUFTD20 I OE Z VDD VSS
MI5-M_u4 net33 I VSS VSS nch w=0.39u l=0.06u
MI5-M_u3 net33 net051 VSS VSS nch w=0.39u l=0.06u
MI12-M_u4 net33 I VSS VSS nch w=0.39u l=0.06u
MI12-M_u3 net33 net051 VSS VSS nch w=0.39u l=0.06u
MI10-M_u4 net33 I VSS VSS nch w=0.39u l=0.06u
MI10-M_u3 net33 net051 VSS VSS nch w=0.39u l=0.06u
MI13-M_u4 XI13-net6 I VSS VSS nch w=0.39u l=0.06u
MI13-M_u3 net26 OE XI13-net6 VSS nch w=0.21u l=0.06u
MI14-M_u4 XI14-net6 I VSS VSS nch w=0.39u l=0.06u
MI14-M_u3 net26 OE XI14-net6 VSS nch w=0.21u l=0.06u
MI7-M_u4 XI7-net6 I VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 net26 OE XI7-net6 VSS nch w=0.39u l=0.06u
M_u17-M_u2 net051 OE VSS VSS nch w=0.39u l=0.06u
M_u7 Z net33 VSS VSS nch w=6.72u l=0.06u
MI5-M_u1 XI5-net8 net051 VDD VDD pch w=0.34u l=0.06u
MI5-M_u2 net33 I XI5-net8 VDD pch w=0.34u l=0.06u
MI12-M_u1 XI12-net8 net051 VDD VDD pch w=0.34u l=0.06u
MI12-M_u2 net33 I XI12-net8 VDD pch w=0.34u l=0.06u
MI10-M_u1 XI10-net8 net051 VDD VDD pch w=0.45u l=0.06u
MI10-M_u2 net33 I XI10-net8 VDD pch w=0.45u l=0.06u
MI13-M_u2 net26 I VDD VDD pch w=0.52u l=0.06u
MI13-M_u1 net26 OE VDD VDD pch w=0.52u l=0.06u
MI14-M_u2 net26 I VDD VDD pch w=0.52u l=0.06u
MI14-M_u1 net26 OE VDD VDD pch w=0.52u l=0.06u
MI7-M_u2 net26 I VDD VDD pch w=0.52u l=0.06u
MI7-M_u1 net26 OE VDD VDD pch w=0.52u l=0.06u
M_u17-M_u3 net051 OE VDD VDD pch w=0.52u l=0.06u
M_u6 Z net26 VDD VDD pch w=9.72u l=0.06u
.ends
.subckt BUFTD24 I OE Z VDD VSS
M_u17_0-M_u2 p0 OE VSS VSS nch w=0.195u l=0.06u
M_u17_1-M_u2 p0 OE VSS VSS nch w=0.195u l=0.06u
M_u7 Z INEN VSS VSS nch w=8.08u l=0.06u
MI5-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MI5-M_u3 INEN p0 VSS VSS nch w=0.39u l=0.06u
MI7-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 INEN p0 VSS VSS nch w=0.39u l=0.06u
MU19-M_u4 INEN I VSS VSS nch w=0.39u l=0.06u
MU19-M_u3 INEN p0 VSS VSS nch w=0.39u l=0.06u
MI10-M_u4 XI10-net6 I VSS VSS nch w=0.39u l=0.06u
MI10-M_u3 INEP OE XI10-net6 VSS nch w=0.21u l=0.06u
MI11-M_u4 XI11-net6 I VSS VSS nch w=0.39u l=0.06u
MI11-M_u3 INEP OE XI11-net6 VSS nch w=0.21u l=0.06u
MU18-M_u4 XU18-net6 I VSS VSS nch w=0.39u l=0.06u
MU18-M_u3 INEP OE XU18-net6 VSS nch w=0.39u l=0.06u
M_u17_0-M_u3 p0 OE VDD VDD pch w=0.26u l=0.06u
M_u17_1-M_u3 p0 OE VDD VDD pch w=0.26u l=0.06u
MI5-M_u1 XI5-net8 p0 VDD VDD pch w=0.45u l=0.06u
MI5-M_u2 INEN I XI5-net8 VDD pch w=0.45u l=0.06u
MI7-M_u1 XI7-net8 p0 VDD VDD pch w=0.34u l=0.06u
MI7-M_u2 INEN I XI7-net8 VDD pch w=0.34u l=0.06u
MU19-M_u1 XU19-net8 p0 VDD VDD pch w=0.34u l=0.06u
MU19-M_u2 INEN I XU19-net8 VDD pch w=0.34u l=0.06u
MI10-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI10-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
MI11-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MI11-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
MU18-M_u2 INEP I VDD VDD pch w=0.52u l=0.06u
MU18-M_u1 INEP OE VDD VDD pch w=0.52u l=0.06u
M_u6 Z INEP VDD VDD pch w=11.68u l=0.06u
.ends
.subckt CKAN2D0 A1 A2 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.15u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.15u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.15u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.195u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.195u l=0.06u
.ends
.subckt CKAN2D1 A1 A2 Z VDD VSS
M_u3-M_u2 Z net6 VSS VSS nch w=0.28u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.195u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.195u l=0.06u
.ends
.subckt CKAN2D2 A1 A2 Z VDD VSS
M_u3-M_u2 Z net10 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u3 net10 A1 X_u2-net6 VSS nch w=0.195u l=0.06u
M_u3-M_u3 Z net10 VDD VDD pch w=1.04u l=0.06u
M_u2-M_u2 net10 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net10 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKAN2D4 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z net10 VSS VSS nch w=0.195u l=0.06u
M_u3_1-M_u2 Z net10 VSS VSS nch w=0.195u l=0.06u
M_u3_2-M_u2 Z net10 VSS VSS nch w=0.195u l=0.06u
M_u3_3-M_u2 Z net10 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u3 net10 A1 X_u2-net6 VSS nch w=0.195u l=0.06u
M_u3_0-M_u3 Z net10 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net10 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z net10 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z net10 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net10 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net10 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKAN2D8 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_1-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_2-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_3-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_4-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_5-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_6-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u3_7-M_u2 Z n0 VSS VSS nch w=0.195u l=0.06u
M_u2_0-M_u4 X_u2_0-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2_0-M_u3 n0 A1 X_u2_0-net6 VSS nch w=0.195u l=0.06u
M_u2_1-M_u4 X_u2_1-net6 A2 VSS VSS nch w=0.195u l=0.06u
M_u2_1-M_u3 n0 A1 X_u2_1-net6 VSS nch w=0.195u l=0.06u
M_u3_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u3_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u2 n0 A2 VDD VDD pch w=0.39u l=0.06u
M_u2_0-M_u1 n0 A1 VDD VDD pch w=0.39u l=0.06u
M_u2_1-M_u2 n0 A2 VDD VDD pch w=0.39u l=0.06u
M_u2_1-M_u1 n0 A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKBD0 I Z VDD VSS
MU23 Z net21 VSS VSS nch w=0.15u l=0.06u
M_u15 net21 I VSS VSS nch w=0.15u l=0.06u
MU21 Z net21 VDD VDD pch w=0.26u l=0.06u
M_u3 net21 I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt CKBD1 I Z VDD VSS
MU23 Z net21 VSS VSS nch w=0.31u l=0.06u
M_u15 net21 I VSS VSS nch w=0.31u l=0.06u
MU21 Z net21 VDD VDD pch w=0.52u l=0.06u
M_u3 net21 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKBD2 I Z VDD VSS
MU23_0 Z net023 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z net023 VSS VSS nch w=0.31u l=0.06u
M_u15 net023 I VSS VSS nch w=0.31u l=0.06u
MU21_0 Z net023 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z net023 VDD VDD pch w=0.52u l=0.06u
M_u3 net023 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKBD3 I Z VDD VSS
MU23_0 Z net023 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z net023 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z net023 VSS VSS nch w=0.31u l=0.06u
M_u15 net023 I VSS VSS nch w=0.31u l=0.06u
MU21_0 Z net023 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z net023 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z net023 VDD VDD pch w=0.52u l=0.06u
M_u3 net023 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKBD4 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15_0 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_1 p0 I VSS VSS nch w=0.31u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKBD6 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_4 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_5 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15 p0 I VSS VSS nch w=0.52u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKBD8 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_4 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_5 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_6 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_7 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15 p0 I VSS VSS nch w=0.78u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_6 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_7 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_2 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKBD12 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_4 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_5 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_6 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_7 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_8 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_9 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_10 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_11 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15 p0 I VSS VSS nch w=1.17u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_6 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_7 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_8 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_9 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_10 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_11 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_2 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_3 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKBD16 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_4 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_5 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_6 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_7 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_8 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_9 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_10 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_11 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_12 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_13 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_14 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_15 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15_0 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_1 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_2 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_3 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_4 p0 I VSS VSS nch w=0.31u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_6 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_7 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_8 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_9 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_10 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_11 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_12 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_13 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_14 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_15 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_2 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_4 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKBD20 I Z VDD VSS
MU23_0 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_1 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_2 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_3 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_4 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_5 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_6 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_7 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_8 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_9 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_10 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_11 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_12 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_13 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_14 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_15 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_16 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_17 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_18 Z p0 VSS VSS nch w=0.31u l=0.06u
MU23_19 Z p0 VSS VSS nch w=0.31u l=0.06u
M_u15_0 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_1 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_2 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_3 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_4 p0 I VSS VSS nch w=0.31u l=0.06u
M_u15_5 p0 I VSS VSS nch w=0.31u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_6 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_7 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_8 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_9 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_10 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_11 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_12 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_13 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_14 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_15 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_16 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_17 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_18 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_19 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_2 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_4 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_5 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKBD24 I Z VDD VSS
MU23 Z p0 VSS VSS nch w=7.35u l=0.06u
M_u15 p0 I VSS VSS nch w=2.1u l=0.06u
MU21_0 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_1 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_2 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_4 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_5 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_6 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_7 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_8 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_9 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_10 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_11 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_12 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_13 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_14 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_15 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_16 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_17 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_18 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_19 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_20 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_21 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_22 Z p0 VDD VDD pch w=0.52u l=0.06u
MU21_23 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_0 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_1 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_2 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_4 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_5 p0 I VDD VDD pch w=0.52u l=0.06u
M_u3_6 p0 I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKLHQD1  Q TE CPN E VDD VSS
MI91 net038 net060 net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net038 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net36 QD VSS VSS nch w=0.23u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net060 VSS VSS nch w=0.195u l=0.06u
MU81-M_u2 net060 CPN VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 d3 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 d3 net36 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net36 QD VDD VDD pch w=0.29u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net060 VDD VDD pch w=0.26u l=0.06u
MU81-M_u3 net060 CPN VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net36 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 d3 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI90 net067 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net067 VDD pch w=0.2u l=0.06u
MU16 net53 net060 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD2  Q TE CPN E VDD VSS
MI92 VSS QD net038 VSS nch w=0.2u l=0.06u
MI91 net038 net059 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI1-M_u4 net38 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net38 net36 VSS VSS nch w=0.39u l=0.06u
MI86-M_u2 Q net38 VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 INCP net059 VSS VSS nch w=0.195u l=0.06u
MI89-M_u2 net36 QD VSS VSS nch w=0.23u l=0.06u
MI96-M_u2 net059 CPN VSS VSS nch w=0.195u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75-M_u2 Q net38 VSS VSS nch w=0.39u l=0.06u
MI1-M_u1 XI1-net8 net36 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net38 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI86-M_u3 Q net38 VDD VDD pch w=0.52u l=0.06u
MI95-M_u3 INCP net059 VDD VDD pch w=0.26u l=0.06u
MI89-M_u3 net36 QD VDD VDD pch w=0.29u l=0.06u
MI96-M_u3 net059 CPN VDD VDD pch w=0.26u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75-M_u3 Q net38 VDD VDD pch w=0.52u l=0.06u
MI90 net068 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net068 VDD pch w=0.2u l=0.06u
MU16 net53 net059 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD3  Q TE CPN E VDD VSS
MI92 VSS QD net038 VSS nch w=0.2u l=0.06u
MI91 net038 net053 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net36 QD VSS VSS nch w=0.23u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net42 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net42 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net42 VSS VSS nch w=0.39u l=0.06u
MU81-M_u2 net053 CPN VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net053 VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net42 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net42 net36 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net36 QD VDD VDD pch w=0.29u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net42 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net42 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net42 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net053 CPN VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net053 VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net36 VDD VDD pch w=0.37u l=0.06u
MI1-M_u2 net42 CPN XI1-net8 VDD pch w=0.37u l=0.06u
MI90 net065 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net065 VDD pch w=0.2u l=0.06u
MU16 net53 net053 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD4  Q TE CPN E VDD VSS
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI91 net039 net056 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU81-M_u2 net056 CPN VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net52 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net52 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net52 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net52 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CPN VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net52 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI90-M_u2 net52 CPN XI90-net8 VDD pch w=0.52u l=0.06u
MI93 net071 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net071 VDD pch w=0.2u l=0.06u
MU16 net53 net056 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD6  Q TE CPN E VDD VSS
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI91 net039 net056 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU81-M_u2 net056 CPN VSS VSS nch w=0.195u l=0.06u
MU75_0-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net52 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net52 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net52 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net52 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net52 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU81-M_u3 net056 CPN VDD VDD pch w=0.26u l=0.06u
MU75_0-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net52 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net52 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI90-M_u2 net52 CPN XI90-net8 VDD pch w=0.52u l=0.06u
MI93 net071 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net071 VDD pch w=0.2u l=0.06u
MU16 net53 net056 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD8  Q TE CPN E VDD VSS
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI91 net039 net056 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_6-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_7-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MU81-M_u2 net056 CPN VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MU81-M_u3 net056 CPN VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net111 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI90-M_u2 net111 CPN XI90-net8 VDD pch w=0.52u l=0.06u
MI95 net072 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net072 VDD pch w=0.2u l=0.06u
MU16 net53 net056 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD12  Q TE CPN E VDD VSS
MI92 VSS QD net047 VSS nch w=0.2u l=0.06u
MI91 net047 net062 net53 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.2u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.36u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU81-M_u2 net062 CPN VSS VSS nch w=0.195u l=0.06u
MU75_0-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_6-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_7-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_8-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_9-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_10-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_11-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net062 VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net111 CPN VSS VSS nch w=0.36u l=0.06u
MI1-M_u3 net111 net85 VSS VSS nch w=0.36u l=0.06u
MI98-M_u4 net111 CPN VSS VSS nch w=0.36u l=0.06u
MI98-M_u3 net111 net85 VSS VSS nch w=0.36u l=0.06u
MI97-M_u4 net111 CPN VSS VSS nch w=0.36u l=0.06u
MI97-M_u3 net111 net85 VSS VSS nch w=0.36u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU81-M_u3 net062 CPN VDD VDD pch w=0.26u l=0.06u
MU75_0-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net062 VDD VDD pch w=0.26u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.46u l=0.06u
MI1-M_u2 net111 CPN XI1-net8 VDD pch w=0.46u l=0.06u
MI98-M_u1 XI98-net8 net85 VDD VDD pch w=0.46u l=0.06u
MI98-M_u2 net111 CPN XI98-net8 VDD pch w=0.46u l=0.06u
MI97-M_u1 XI97-net8 net85 VDD VDD pch w=0.46u l=0.06u
MI97-M_u2 net111 CPN XI97-net8 VDD pch w=0.46u l=0.06u
MI96 net080 INCP net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net080 VDD pch w=0.2u l=0.06u
MU16 net53 net062 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLHQD16  Q TE CPN E VDD VSS
MI92 VSS QD net054 VSS nch w=0.16u l=0.06u
MI91 net054 net069 net53 VSS nch w=0.16u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.16u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_6-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_7-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_8-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_9-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_10-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_11-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_12-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_13-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_14-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_15-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net069 VSS VSS nch w=0.195u l=0.06u
MU81-M_u2 net069 CPN VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI95-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI95-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI97-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI97-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net069 VDD VDD pch w=0.26u l=0.06u
MU81-M_u3 net069 CPN VDD VDD pch w=0.26u l=0.06u
MI98 net081 INCP net53 VDD pch w=0.18u l=0.06u
MI88 VDD QD net081 VDD pch w=0.18u l=0.06u
MU16 net53 net069 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net111 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI95-M_u1 XI95-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI95-M_u2 net111 CPN XI95-net8 VDD pch w=0.52u l=0.06u
MI97-M_u1 XI97-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI97-M_u2 net111 CPN XI97-net8 VDD pch w=0.52u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI90-M_u2 net111 CPN XI90-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt CKLHQD20  Q TE CPN E VDD VSS
MI92 VSS QD net052 VSS nch w=0.16u l=0.06u
MI91 net052 net069 net53 VSS nch w=0.16u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.16u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_6-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_7-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_8-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_9-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_10-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_11-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_12-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_13-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_14-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_15-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_16-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_17-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_18-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_19-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net069 VSS VSS nch w=0.195u l=0.06u
MU81-M_u2 net069 CPN VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI95-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI95-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI97-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI97-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_16-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_17-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_18-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_19-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net069 VDD VDD pch w=0.26u l=0.06u
MU81-M_u3 net069 CPN VDD VDD pch w=0.26u l=0.06u
MI98 net081 INCP net53 VDD pch w=0.18u l=0.06u
MI88 VDD QD net081 VDD pch w=0.18u l=0.06u
MU16 net53 net069 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net111 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI95-M_u1 XI95-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI95-M_u2 net111 CPN XI95-net8 VDD pch w=0.52u l=0.06u
MI97-M_u1 XI97-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI97-M_u2 net111 CPN XI97-net8 VDD pch w=0.52u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI90-M_u2 net111 CPN XI90-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt CKLHQD24  Q TE CPN E VDD VSS
MI92 VSS QD net057 VSS nch w=0.16u l=0.06u
MI91 net057 net072 net53 VSS nch w=0.16u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 INCP net50 VSS nch w=0.16u l=0.06u
MI89-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 net85 QD VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.23u l=0.06u
MU75_0-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_1-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_2-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_3-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_4-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_5-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_6-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_7-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_8-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_9-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_10-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_11-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_12-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_13-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_14-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_15-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_16-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_17-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_18-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_19-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_20-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_21-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_22-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU75_23-M_u2 Q net111 VSS VSS nch w=0.39u l=0.06u
MU82-M_u2 INCP net072 VSS VSS nch w=0.195u l=0.06u
MU81-M_u2 net072 CPN VSS VSS nch w=0.195u l=0.06u
MI1-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI95-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI95-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI98-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI98-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI97-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI97-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI90-M_u4 net111 CPN VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 net111 net85 VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 net85 QD VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_16-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_17-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_18-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_19-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_20-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_21-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_22-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU75_23-M_u3 Q net111 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net072 VDD VDD pch w=0.26u l=0.06u
MU81-M_u3 net072 CPN VDD VDD pch w=0.26u l=0.06u
MI99 net083 INCP net53 VDD pch w=0.18u l=0.06u
MI88 VDD QD net083 VDD pch w=0.18u l=0.06u
MU16 net53 net072 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
MI1-M_u1 XI1-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net111 CPN XI1-net8 VDD pch w=0.52u l=0.06u
MI95-M_u1 XI95-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI95-M_u2 net111 CPN XI95-net8 VDD pch w=0.52u l=0.06u
MI98-M_u1 XI98-net8 net85 VDD VDD pch w=0.52u l=0.06u
MI98-M_u2 net111 CPN XI98-net8 VDD pch w=0.52u l=0.06u
MI97-M_u1 XI97-net8 net85 VDD VDD pch w=0.45u l=0.06u
MI97-M_u2 net111 CPN XI97-net8 VDD pch w=0.45u l=0.06u
MI90-M_u1 XI90-net8 net85 VDD VDD pch w=0.45u l=0.06u
MI90-M_u2 net111 CPN XI90-net8 VDD pch w=0.45u l=0.06u
.ends
.subckt CKLNQD1 TE E CP Q VDD VSS
MI91 net033 net055 net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net033 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net057 net50 VSS nch w=0.27u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.215u l=0.06u
MU82-M_u2 net055 net057 VSS VSS nch w=0.195u l=0.06u
MU75-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net057 CP VSS VSS nch w=0.195u l=0.06u
MI85-M_u4 XI85-net6 QD VSS VSS nch w=0.215u l=0.06u
MI85-M_u3 d3 CP XI85-net6 VSS nch w=0.215u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU82-M_u3 net055 net057 VDD VDD pch w=0.26u l=0.06u
MU75-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net057 CP VDD VDD pch w=0.26u l=0.06u
MI85-M_u2 d3 QD VDD VDD pch w=0.35u l=0.06u
MI85-M_u1 d3 CP VDD VDD pch w=0.35u l=0.06u
MI90 net062 net057 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 net055 net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD2 TE E CP Q VDD VSS
MI91 net039 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI86 net50 E VSS VSS nch w=0.27u l=0.06u
MI87 net50 TE VSS VSS nch w=0.27u l=0.06u
MI82 net53 net053 net50 VSS nch w=0.27u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU81-M_u2 net053 CP VSS VSS nch w=0.195u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU82-M_u2 INCP net053 VSS VSS nch w=0.195u l=0.06u
MI85-M_u4 XI85-net6 QD VSS VSS nch w=0.215u l=0.06u
MI85-M_u3 d3 CP XI85-net6 VSS nch w=0.215u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU81-M_u3 net053 CP VDD VDD pch w=0.26u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU82-M_u3 INCP net053 VDD VDD pch w=0.26u l=0.06u
MI85-M_u2 d3 QD VDD VDD pch w=0.35u l=0.06u
MI85-M_u1 d3 CP VDD VDD pch w=0.35u l=0.06u
MI90 net062 net053 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD3 TE E CP Q VDD VSS
MI91 net033 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net033 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net053 net50 VSS nch w=0.27u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net053 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net053 VSS VSS nch w=0.195u l=0.06u
MI85-M_u4 XI85-net6 QD VSS VSS nch w=0.215u l=0.06u
MI85-M_u3 d3 CP XI85-net6 VSS nch w=0.215u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net053 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net053 VDD VDD pch w=0.26u l=0.06u
MI85-M_u2 d3 QD VDD VDD pch w=0.35u l=0.06u
MI85-M_u1 d3 CP VDD VDD pch w=0.35u l=0.06u
MI90 net062 net053 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD4 TE E CP Q VDD VSS
MI91 net039 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI87 net50 TE VSS VSS nch w=0.27u l=0.06u
MI86 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net053 net50 VSS nch w=0.27u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net053 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net053 VSS VSS nch w=0.195u l=0.06u
MI85-M_u4 XI85-net6 QD VSS VSS nch w=0.215u l=0.06u
MI85-M_u3 d3 CP XI85-net6 VSS nch w=0.215u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net053 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net053 VDD VDD pch w=0.26u l=0.06u
MI85-M_u2 d3 QD VDD VDD pch w=0.35u l=0.06u
MI85-M_u1 d3 CP VDD VDD pch w=0.35u l=0.06u
MI90 net062 net053 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD6 TE E CP Q VDD VSS
MI91 net039 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI89 net50 TE VSS VSS nch w=0.27u l=0.06u
MI87 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI86_0-M_u4 XI86_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_0-M_u3 d3 QD XI86_0-net6 VSS nch w=0.215u l=0.06u
MI86_1-M_u4 XI86_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_1-M_u3 d3 QD XI86_1-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI86_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net061 net056 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net061 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD8 TE E CP Q VDD VSS
MI91 net039 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI89 net50 TE VSS VSS nch w=0.27u l=0.06u
MI87 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI86_0-M_u4 XI86_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_0-M_u3 d3 QD XI86_0-net6 VSS nch w=0.215u l=0.06u
MI86_1-M_u4 XI86_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_1-M_u3 d3 QD XI86_1-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_6-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_7-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI86_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net061 net056 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net061 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD12 TE E CP Q VDD VSS
MI91 net039 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net039 VSS nch w=0.2u l=0.06u
MI97 net50 TE VSS VSS nch w=0.27u l=0.06u
MI96 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI88_0-M_u4 XI88_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI88_0-M_u3 d3 QD XI88_0-net6 VSS nch w=0.215u l=0.06u
MI88_1-M_u4 XI88_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI88_1-M_u3 d3 QD XI88_1-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_6-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_7-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_8-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_9-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_10-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_11-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI88_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI88_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI88_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI88_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.34u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net062 net056 net53 VDD pch w=0.2u l=0.06u
MI93 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD16 TE E CP Q VDD VSS
MI91 net037 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net037 VSS nch w=0.2u l=0.06u
MU19 net50 TE VSS VSS nch w=0.27u l=0.06u
MU20 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI86_0-M_u4 XI86_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_0-M_u3 d3 QD XI86_0-net6 VSS nch w=0.215u l=0.06u
MI86_1-M_u4 XI86_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_1-M_u3 d3 QD XI86_1-net6 VSS nch w=0.215u l=0.06u
MI86_2-M_u4 XI86_2-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_2-M_u3 d3 QD XI86_2-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_6-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_7-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_8-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_9-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_10-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_11-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_12-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_13-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_14-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_15-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI86_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net061 net056 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net061 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD20 TE E CP Q VDD VSS
MI91 net043 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net043 VSS nch w=0.2u l=0.06u
MI87 net50 E VSS VSS nch w=0.27u l=0.06u
MI89 net50 TE VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI86_0-M_u4 XI86_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_0-M_u3 d3 QD XI86_0-net6 VSS nch w=0.215u l=0.06u
MI86_1-M_u4 XI86_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_1-M_u3 d3 QD XI86_1-net6 VSS nch w=0.215u l=0.06u
MI86_2-M_u4 XI86_2-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_2-M_u3 d3 QD XI86_2-net6 VSS nch w=0.215u l=0.06u
MI86_3-M_u4 XI86_3-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_3-M_u3 d3 QD XI86_3-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_6-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_7-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_8-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_9-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_10-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_11-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_12-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_13-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_14-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_15-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_16-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_17-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_18-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_19-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI86_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_3-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_3-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_16-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_17-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_18-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_19-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net062 net056 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKLNQD24 TE E CP Q VDD VSS
MI91 net043 INCP net53 VSS nch w=0.2u l=0.06u
MI92 VSS QD net043 VSS nch w=0.2u l=0.06u
MI89 net50 TE VSS VSS nch w=0.27u l=0.06u
MI87 net50 E VSS VSS nch w=0.27u l=0.06u
MI82 net53 net056 net50 VSS nch w=0.27u l=0.06u
MI86_0-M_u4 XI86_0-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_0-M_u3 d3 QD XI86_0-net6 VSS nch w=0.215u l=0.06u
MI86_1-M_u4 XI86_1-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_1-M_u3 d3 QD XI86_1-net6 VSS nch w=0.215u l=0.06u
MI86_2-M_u4 XI86_2-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_2-M_u3 d3 QD XI86_2-net6 VSS nch w=0.215u l=0.06u
MI86_3-M_u4 XI86_3-net6 CP VSS VSS nch w=0.215u l=0.06u
MI86_3-M_u3 d3 QD XI86_3-net6 VSS nch w=0.215u l=0.06u
MI80-M_u2 QD net53 VSS VSS nch w=0.2u l=0.06u
MU75_0-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_1-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_2-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_3-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_4-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_5-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_6-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_7-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_8-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_9-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_10-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_11-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_12-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_13-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_14-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_15-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_16-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_17-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_18-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_19-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_20-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_21-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_22-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU75_23-M_u2 Q d3 VSS VSS nch w=0.215u l=0.06u
MU81-M_u2 net056 CP VSS VSS nch w=0.195u l=0.06u
MU82-M_u2 INCP net056 VSS VSS nch w=0.195u l=0.06u
MI86_0-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_0-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_1-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_2-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI86_3-M_u2 d3 CP VDD VDD pch w=0.35u l=0.06u
MI86_3-M_u1 d3 QD VDD VDD pch w=0.35u l=0.06u
MI80-M_u3 QD net53 VDD VDD pch w=0.285u l=0.06u
MU75_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_4-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_5-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_6-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_7-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_8-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_9-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_10-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_11-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_12-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_13-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_14-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_15-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_16-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_17-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_18-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_19-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_20-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_21-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_22-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU75_23-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MU81-M_u3 net056 CP VDD VDD pch w=0.26u l=0.06u
MU82-M_u3 INCP net056 VDD VDD pch w=0.26u l=0.06u
MI90 net062 net056 net53 VDD pch w=0.2u l=0.06u
MI88 VDD QD net062 VDD pch w=0.2u l=0.06u
MU16 net53 INCP net61 VDD pch w=0.48u l=0.06u
MU17 net61 E net58 VDD pch w=0.48u l=0.06u
MI81 net58 TE VDD VDD pch w=0.48u l=0.06u
.ends
.subckt CKMUX2D0 I0 I1 S Z VDD VSS
MU29-M_u2 Z net28 VSS VSS nch w=0.15u l=0.06u
MI111 net47 I0 VSS VSS nch w=0.15u l=0.06u
MI5 net28 net6 net47 VSS nch w=0.15u l=0.06u
MI14 net44 I1 VSS VSS nch w=0.15u l=0.06u
MI13 net28 S net44 VSS nch w=0.15u l=0.06u
MU24 net6 S VSS VSS nch w=0.15u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.26u l=0.06u
MI2 VDD I0 net47 VDD pch w=0.26u l=0.06u
MI4 net47 S net28 VDD pch w=0.26u l=0.06u
MI12 net44 net6 net28 VDD pch w=0.26u l=0.06u
MI10 VDD I1 net44 VDD pch w=0.26u l=0.06u
MU25 VDD S net6 VDD pch w=0.26u l=0.06u
.ends
.subckt CKMUX2D1 I0 I1 S Z VDD VSS
MU29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI111 net47 I0 VSS VSS nch w=0.195u l=0.06u
MI5 net28 net6 net47 VSS nch w=0.195u l=0.06u
MI7 net28 S net44 VSS nch w=0.195u l=0.06u
MI8 net44 I1 VSS VSS nch w=0.39u l=0.06u
MU24 net6 S VSS VSS nch w=0.195u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI2 VDD I0 net47 VDD pch w=0.34u l=0.06u
MI4 net47 S net28 VDD pch w=0.255u l=0.06u
MI9 net44 net6 net28 VDD pch w=0.255u l=0.06u
MI10 VDD I1 net44 VDD pch w=0.52u l=0.06u
MU25 VDD S net6 VDD pch w=0.26u l=0.06u
.ends
.subckt CKMUX2D2 I0 I1 S Z VDD VSS
MI28_0-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MI28_1-M_u2 Z net43 VSS VSS nch w=0.39u l=0.06u
MI15 net49 I0 VSS VSS nch w=0.195u l=0.06u
MI16 net43 net53 net49 VSS nch w=0.195u l=0.06u
MI17 net43 S net40 VSS nch w=0.195u l=0.06u
MI18 net40 I1 VSS VSS nch w=0.39u l=0.06u
MI19 net53 S VSS VSS nch w=0.195u l=0.06u
MI28_0-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI28_1-M_u3 Z net43 VDD VDD pch w=0.52u l=0.06u
MI20 VDD I0 net49 VDD pch w=0.34u l=0.06u
MI21 net49 S net43 VDD pch w=0.255u l=0.06u
MI22 net40 net53 net43 VDD pch w=0.255u l=0.06u
MI23 VDD I1 net40 VDD pch w=0.52u l=0.06u
MI24 VDD S net53 VDD pch w=0.26u l=0.06u
.ends
.subckt CKMUX2D4 I0 I1 S Z VDD VSS
MI14_0-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI14_1-M_u2 net45 I1 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 net47 I0 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net47 I0 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.195u l=0.06u
MU29_0-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_1-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_2-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU29_3-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MU18-M_u3 net47 net6 net28 VSS nch w=0.19u l=0.06u
MI13-M_u3 net45 S net28 VSS nch w=0.19u l=0.06u
MI14_0-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI14_1-M_u3 net45 I1 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net47 I0 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net47 I0 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.26u l=0.06u
MU29_0-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_1-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_2-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU29_3-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MU18-M_u2 net47 S net28 VDD pch w=0.26u l=0.06u
MI13-M_u2 net45 net6 net28 VDD pch w=0.26u l=0.06u
.ends
.subckt CKND0 I ZN VDD VSS
M_u2 ZN I VSS VSS nch w=0.15u l=0.06u
M_u1 ZN I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt CKND1 I ZN VDD VSS
M_u2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKND2 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKND3 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKND4 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKND6 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND8 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_6 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_7 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_6 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_7 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND12 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_6 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_7 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_8 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_9 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_10 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_11 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_6 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_7 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_8 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_9 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_10 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_11 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND16 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_6 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_7 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_8 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_9 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_10 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_11 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_12 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_13 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_14 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_15 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_6 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_7 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_8 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_9 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_10 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_11 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_12 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_13 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_14 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_15 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND20 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_6 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_7 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_8 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_9 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_10 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_11 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_12 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_13 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_14 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_15 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_16 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_17 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_18 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_19 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_6 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_7 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_8 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_9 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_10 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_11 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_12 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_13 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_14 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_15 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_16 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_17 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_18 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_19 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND24 I ZN VDD VSS
M_u2_0 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_1 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_2 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_3 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_4 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_5 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_6 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_7 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_8 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_9 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_10 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_11 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_12 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_13 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_14 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_15 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_16 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_17 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_18 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_19 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_20 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_21 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_22 ZN I VSS VSS nch w=0.31u l=0.06u
M_u2_23 ZN I VSS VSS nch w=0.31u l=0.06u
M_u1_0 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_1 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_2 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_3 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_4 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_5 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_6 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_7 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_8 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_9 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_10 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_11 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_12 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_13 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_14 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_15 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_16 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_17 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_18 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_19 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_20 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_21 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_22 ZN I VDD VDD pch w=0.52u l=0.06u
M_u1_23 ZN I VDD VDD pch w=0.52u l=0.06u
DI3 VSS I ndio area=0.066p pj=1.18u
.ends
.subckt CKND2D0 A1 A2 ZN VDD VSS
MU1-M_u4 XU1-net6 A2 VSS VSS nch w=0.195u l=0.06u
MU1-M_u3 ZN A1 XU1-net6 VSS nch w=0.195u l=0.06u
MU1-M_u2 ZN A2 VDD VDD pch w=0.195u l=0.06u
MU1-M_u1 ZN A1 VDD VDD pch w=0.195u l=0.06u
.ends
.subckt CKND2D1 A1 A2 ZN VDD VSS
MI0-M_u4 XI0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI0-M_u3 ZN A1 XI0-net6 VSS nch w=0.39u l=0.06u
MI0-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI0-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKND2D2 A1 A2 ZN VDD VSS
MI0_0-M_u4 XI0_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI0_0-M_u3 ZN A1 XI0_0-net6 VSS nch w=0.39u l=0.06u
MI0_1-M_u4 XI0_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI0_1-M_u3 ZN A1 XI0_1-net6 VSS nch w=0.39u l=0.06u
MI0_0-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI0_0-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI0_1-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI0_1-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKND2D3 A1 A2 ZN VDD VSS
MI1_0-M_u4 XI1_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1_0-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1_1-net6 VSS nch w=0.39u l=0.06u
MI1_2-M_u4 XI1_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A1 XI1_2-net6 VSS nch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKND2D4 A1 A2 ZN VDD VSS
MI1_0-M_u4 XI1_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1_0-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1_1-net6 VSS nch w=0.39u l=0.06u
MI1_2-M_u4 XI1_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A1 XI1_2-net6 VSS nch w=0.39u l=0.06u
MI1_3-M_u4 XI1_3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_3-M_u3 ZN A1 XI1_3-net6 VSS nch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_3-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_3-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKND2D8 A1 A2 ZN VDD VSS
MI32-M_u4 XI32-net6 A2 VSS VSS nch w=0.23u l=0.06u
MI32-M_u3 ZN A1 XI32-net6 VSS nch w=0.23u l=0.06u
MI33-M_u4 XI33-net6 A2 VSS VSS nch w=0.23u l=0.06u
MI33-M_u3 ZN A1 XI33-net6 VSS nch w=0.23u l=0.06u
MI1_0-M_u4 XI1_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1_0-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1_1-net6 VSS nch w=0.39u l=0.06u
MI1_2-M_u4 XI1_2-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A1 XI1_2-net6 VSS nch w=0.39u l=0.06u
MI1_3-M_u4 XI1_3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_3-M_u3 ZN A1 XI1_3-net6 VSS nch w=0.39u l=0.06u
MI1_4-M_u4 XI1_4-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_4-M_u3 ZN A1 XI1_4-net6 VSS nch w=0.39u l=0.06u
MI1_5-M_u4 XI1_5-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_5-M_u3 ZN A1 XI1_5-net6 VSS nch w=0.39u l=0.06u
MI32-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI32-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI33-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI33-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_2-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_3-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_3-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_4-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_4-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
MI1_5-M_u2 ZN A2 VDD VDD pch w=0.39u l=0.06u
MI1_5-M_u1 ZN A1 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt CKXOR2D0 A1 A2 Z VDD VSS
M_u6-M_u3 net4 net10 net14 VSS nch w=0.15u l=0.06u
MI3-M_u3 net6 A1 net14 VSS nch w=0.15u l=0.06u
MI1-M_u2 net4 A2 VSS VSS nch w=0.15u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.15u l=0.06u
M_u4-M_u2 Z net14 VSS VSS nch w=0.15u l=0.06u
MI2-M_u2 net10 A1 VSS VSS nch w=0.15u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.26u l=0.06u
MI3-M_u2 net6 net10 net14 VDD pch w=0.26u l=0.06u
MI1-M_u3 net4 A2 VDD VDD pch w=0.26u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u3 Z net14 VDD VDD pch w=0.26u l=0.06u
MI2-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt CKXOR2D1 A1 A2 Z VDD VSS
M_u6-M_u3 net4 net10 net14 VSS nch w=0.195u l=0.06u
MI0-M_u3 net6 A1 net14 VSS nch w=0.195u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.195u l=0.06u
M_u4-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.29u l=0.06u
MI0-M_u2 net6 net10 net14 VDD pch w=0.29u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.29u l=0.06u
M_u4-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt CKXOR2D2 A1 A2 Z VDD VSS
M_u6-M_u3 net4 net10 net14 VSS nch w=0.195u l=0.06u
MI0-M_u3 net6 A1 net14 VSS nch w=0.195u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.195u l=0.06u
M_u4_0-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.29u l=0.06u
MI0-M_u2 net6 net10 net14 VDD pch w=0.29u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.29u l=0.06u
M_u4_0-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CKXOR2D4 A1 A2 Z VDD VSS
M_u6_0-M_u3 net26 net29 p0 VSS nch w=0.275u l=0.06u
M_u6_1-M_u3 net26 net29 p0 VSS nch w=0.275u l=0.06u
MI0_0-M_u3 net6 A1 p0 VSS nch w=0.275u l=0.06u
MI0_1-M_u3 net6 A1 p0 VSS nch w=0.275u l=0.06u
M_u2_0-M_u2 net26 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 net26 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 net26 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net26 VSS VSS nch w=0.39u l=0.06u
M_u4_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net29 A1 VSS VSS nch w=0.39u l=0.06u
M_u6_0-M_u2 net26 A1 p0 VDD pch w=0.44u l=0.06u
M_u6_1-M_u2 net26 A1 p0 VDD pch w=0.44u l=0.06u
MI0_0-M_u2 net6 net29 p0 VDD pch w=0.395u l=0.06u
MI0_1-M_u2 net6 net29 p0 VDD pch w=0.395u l=0.06u
M_u2_0-M_u3 net26 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 net26 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 net26 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net26 VDD VDD pch w=0.52u l=0.06u
M_u4_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net29 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt CMPE42D1 A B C D CIX S COX CO VDD VSS
MI30_0-M_u2 net158 net34 VSS VSS nch w=0.39u l=0.06u
MI30_1-M_u2 net158 net34 VSS VSS nch w=0.39u l=0.06u
MI39-M_u2 net152 SUMXB VSS VSS nch w=0.35u l=0.06u
MI32-M_u2 net156 net67 VSS VSS nch w=0.35u l=0.06u
MI23-M_u2 S net72 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 net126 D VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 CO net94 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 net122 CIX VSS VSS nch w=0.35u l=0.06u
MI28-M_u2 net120 net80 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net154 net122 VSS VSS nch w=0.35u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.195u l=0.06u
MU28-M_u2 COX net24 VSS VSS nch w=0.35u l=0.06u
MI37-M_u2 net67 C VSS VSS nch w=0.35u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI45-M_u3 net36 net44 net24 VSS nch w=0.23u l=0.06u
MI49-M_u3 net158 net36 net32 VSS nch w=0.325u l=0.06u
MI48-M_u3 net67 net44 SUMXB VSS nch w=0.17u l=0.06u
MI50-M_u3 net34 B net32 VSS nch w=0.23u l=0.06u
MI46-M_u3 net67 net32 net24 VSS nch w=0.32u l=0.06u
MI43-M_u3 net152 net126 net80 VSS nch w=0.37u l=0.06u
MI47-M_u3 net156 net32 SUMXB VSS nch w=0.35u l=0.06u
MI44-M_u3 SUMXB D net80 VSS nch w=0.23u l=0.06u
MI33-M_u3 net154 net80 net72 VSS nch w=0.32u l=0.06u
MI42-M_u3 net126 net120 net94 VSS nch w=0.21u l=0.06u
MI41-M_u3 net122 net80 net94 VSS nch w=0.32u l=0.06u
MI40-M_u3 net122 net120 net72 VSS nch w=0.17u l=0.06u
MI30_0-M_u3 net158 net34 VDD VDD pch w=0.52u l=0.06u
MI30_1-M_u3 net158 net34 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 net152 SUMXB VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net156 net67 VDD VDD pch w=0.56u l=0.06u
MI23-M_u3 S net72 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 net126 D VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 CO net94 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 net122 CIX VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net120 net80 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net154 net122 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.26u l=0.06u
MU28-M_u3 COX net24 VDD VDD pch w=0.56u l=0.06u
MI37-M_u3 net67 C VDD VDD pch w=0.56u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI45-M_u2 net36 net32 net24 VDD pch w=0.41u l=0.06u
MI49-M_u2 net158 B net32 VDD pch w=0.4u l=0.06u
MI48-M_u2 net67 net32 SUMXB VDD pch w=0.275u l=0.06u
MI50-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI46-M_u2 net67 net44 net24 VDD pch w=0.465u l=0.06u
MI43-M_u2 net152 D net80 VDD pch w=0.42u l=0.06u
MI47-M_u2 net156 net44 SUMXB VDD pch w=0.455u l=0.06u
MI44-M_u2 SUMXB net126 net80 VDD pch w=0.34u l=0.06u
MI33-M_u2 net154 net120 net72 VDD pch w=0.455u l=0.06u
MI42-M_u2 net126 net80 net94 VDD pch w=0.41u l=0.06u
MI41-M_u2 net122 net120 net94 VDD pch w=0.465u l=0.06u
MI40-M_u2 net122 net80 net72 VDD pch w=0.275u l=0.06u
.ends
.subckt CMPE42D2 A B C D CIX S COX CO VDD VSS
MI30_0-M_u2 net158 net34 VSS VSS nch w=0.39u l=0.06u
MI30_1-M_u2 net158 net34 VSS VSS nch w=0.39u l=0.06u
MI37-M_u2 S net72 VSS VSS nch w=0.39u l=0.06u
MI38-M_u2 CO net94 VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 net152 SUMXB VSS VSS nch w=0.37u l=0.06u
MI32-M_u2 net156 net67 VSS VSS nch w=0.35u l=0.06u
MI23-M_u2 S net72 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 net126 D VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 CO net94 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 net122 CIX VSS VSS nch w=0.35u l=0.06u
MI28-M_u2 net120 net80 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 net154 net122 VSS VSS nch w=0.35u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.195u l=0.06u
MU28-M_u2 COX net24 VSS VSS nch w=0.37u l=0.06u
MU26-M_u2 net67 C VSS VSS nch w=0.35u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI46-M_u3 net154 net80 net72 VSS nch w=0.32u l=0.06u
MI44-M_u3 net152 net126 net80 VSS nch w=0.32u l=0.06u
MI49-M_u3 net126 net120 net94 VSS nch w=0.21u l=0.06u
MI43-M_u3 net36 net44 net24 VSS nch w=0.21u l=0.06u
MI47-M_u3 net122 net120 net72 VSS nch w=0.17u l=0.06u
MI48-M_u3 net122 net80 net94 VSS nch w=0.32u l=0.06u
MI40-M_u3 net156 net32 SUMXB VSS nch w=0.32u l=0.06u
MI45-M_u3 SUMXB D net80 VSS nch w=0.23u l=0.06u
MI41-M_u3 net67 net44 SUMXB VSS nch w=0.17u l=0.06u
MI39-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI29-M_u3 net158 net36 net32 VSS nch w=0.32u l=0.06u
MI42-M_u3 net67 net32 net24 VSS nch w=0.32u l=0.06u
MI30_0-M_u3 net158 net34 VDD VDD pch w=0.52u l=0.06u
MI30_1-M_u3 net158 net34 VDD VDD pch w=0.52u l=0.06u
MI37-M_u3 S net72 VDD VDD pch w=0.52u l=0.06u
MI38-M_u3 CO net94 VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 net152 SUMXB VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 net156 net67 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 S net72 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 net126 D VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 CO net94 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 net122 CIX VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net120 net80 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 net154 net122 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.26u l=0.06u
MU28-M_u3 COX net24 VDD VDD pch w=0.52u l=0.06u
MU26-M_u3 net67 C VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI46-M_u2 net154 net120 net72 VDD pch w=0.45u l=0.06u
MI44-M_u2 net152 D net80 VDD pch w=0.41u l=0.06u
MI49-M_u2 net126 net80 net94 VDD pch w=0.41u l=0.06u
MI43-M_u2 net36 net32 net24 VDD pch w=0.41u l=0.06u
MI47-M_u2 net122 net80 net72 VDD pch w=0.26u l=0.06u
MI48-M_u2 net122 net120 net94 VDD pch w=0.45u l=0.06u
MI40-M_u2 net156 net44 SUMXB VDD pch w=0.45u l=0.06u
MI45-M_u2 SUMXB net126 net80 VDD pch w=0.34u l=0.06u
MI41-M_u2 net67 net32 SUMXB VDD pch w=0.26u l=0.06u
MI39-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI29-M_u2 net158 B net32 VDD pch w=0.41u l=0.06u
MI42-M_u2 net67 net44 net24 VDD pch w=0.45u l=0.06u
.ends
.subckt DCAP VDD VSS
M_u2 net8 net6 VSS VSS nch w=0.345u l=0.06u
M_u1 net6 net8 VDD VDD pch w=0.485u l=0.06u
.ends
.subckt DCAP4 VDD VSS
M_u2 net8 net6 VSS VSS nch w=0.33u l=0.06u
MI4 VSS net6 VSS VSS nch w=0.33u l=0.08u
MI3 VDD net8 VDD VDD pch w=0.46u l=0.08u
M_u1 net6 net8 VDD VDD pch w=0.46u l=0.06u
.ends
.subckt DCAP8 VDD VSS
M_u2 net8 net6 VSS VSS nch w=0.3u l=0.06u
MI4 VSS net6 VSS VSS nch w=0.3u l=0.88u
MI3 VDD net8 VDD VDD pch w=0.43u l=0.88u
M_u1 net6 net8 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt DCAP16 VDD VSS
MI4 VSS net6 VSS VSS nch w=0.3u l=0.69u
MI7 VSS net6 VSS VSS nch w=0.3u l=0.69u
MI8 VSS net6 VSS VSS nch w=0.3u l=0.69u
M_u2 net8 net6 VSS VSS nch w=0.3u l=0.06u
MI3 VDD net8 VDD VDD pch w=0.43u l=0.69u
MI5 VDD net8 VDD VDD pch w=0.43u l=0.69u
MI6 VDD net8 VDD VDD pch w=0.43u l=0.69u
M_u1 net6 net8 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt DCAP32 VDD VSS
MI37 VSS net6 VSS VSS nch w=0.3u l=0.975u
MI39 VSS net6 VSS VSS nch w=0.3u l=0.975u
MI36 VSS net6 VSS VSS nch w=0.3u l=0.975u
MI38 VSS net6 VSS VSS nch w=0.3u l=0.975u
MI6 VSS net6 VSS VSS nch w=0.3u l=0.975u
M_u2 net8 net6 VSS VSS nch w=0.3u l=0.06u
MI33 VDD net8 VDD VDD pch w=0.43u l=0.975u
MI32 VDD net8 VDD VDD pch w=0.43u l=0.975u
MI26 VDD net8 VDD VDD pch w=0.43u l=0.975u
MI35 VDD net8 VDD VDD pch w=0.43u l=0.975u
MI34 VDD net8 VDD VDD pch w=0.43u l=0.975u
M_u1 net6 net8 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt DCAP64 VDD VSS
MI69 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI68 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI49 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI60 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI61 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI62 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI63 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI65 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI66 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI64 VSS net6 VSS VSS nch w=0.3u l=0.915u
MI67 VSS net6 VSS VSS nch w=0.3u l=0.915u
M_u2 net8 net6 VSS VSS nch w=0.3u l=0.06u
MI58 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI59 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI57 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI39 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI52 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI51 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI50 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI56 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI55 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI54 VDD net8 VDD VDD pch w=0.43u l=0.915u
MI53 VDD net8 VDD VDD pch w=0.43u l=0.915u
M_u1 net6 net8 VDD VDD pch w=0.39u l=0.06u
.ends
.subckt DEL0 I Z VDD VSS
MI2-M_u2 Z net3 VSS VSS nch w=0.39u l=0.06u
MU7-M_u2 net3 net5 VSS VSS nch w=0.39u l=0.6u
MU5-M_u2 net5 net9 VSS VSS nch w=0.39u l=0.6u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 Z net3 VDD VDD pch w=0.52u l=0.06u
MU7-M_u3 net3 net5 VDD VDD pch w=0.52u l=0.6u
MU5-M_u3 net5 net9 VDD VDD pch w=0.52u l=0.6u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL005 I Z VDD VSS
MI2-M_u2 Z net9 VSS VSS nch w=0.39u l=0.06u
MI13 net6 I VSS VSS nch w=0.39u l=0.06u
MI12 net9 I net6 VSS nch w=0.39u l=0.06u
MI2-M_u3 Z net9 VDD VDD pch w=0.52u l=0.06u
MI10 net9 I net6 VDD pch w=0.52u l=0.06u
MI3 net6 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL01 I Z VDD VSS
MI12 net3 net27 net21 VSS nch w=0.39u l=0.06u
MI13 net21 net27 VSS VSS nch w=0.39u l=0.06u
MI5 net27 net9 net30 VSS nch w=0.39u l=0.06u
MI4 net30 net9 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 Z net3 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI6 net27 net9 net30 VDD pch w=0.52u l=0.06u
MI7 net30 net9 VDD VDD pch w=0.52u l=0.06u
MI3 net21 net27 VDD VDD pch w=0.52u l=0.06u
MI10 net3 net27 net21 VDD pch w=0.52u l=0.06u
MI2-M_u3 Z net3 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL015 I Z VDD VSS
MI35 net27 net9 net85 VSS nch w=0.39u l=0.06u
MI36 net85 net9 net029 VSS nch w=0.39u l=0.06u
MI28 net3 net27 net82 VSS nch w=0.39u l=0.06u
MI37 net029 net9 VSS VSS nch w=0.39u l=0.06u
MI30 net45 net27 VSS VSS nch w=0.39u l=0.06u
MI29 net82 net27 net45 VSS nch w=0.39u l=0.06u
MI2-M_u2 Z net3 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI31 net85 net9 net60 VDD pch w=0.52u l=0.06u
MI32 net27 net9 net85 VDD pch w=0.52u l=0.06u
MI20 net35 net27 VDD VDD pch w=0.52u l=0.06u
MI21 net82 net27 net35 VDD pch w=0.52u l=0.06u
MI7 net60 net9 VDD VDD pch w=0.52u l=0.06u
MI23 net3 net27 net82 VDD pch w=0.52u l=0.06u
MI2-M_u3 Z net3 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL02 I Z VDD VSS
MI28 net82 net27 net47 VSS nch w=0.3u l=0.06u
MI29 net47 net27 VSS VSS nch w=0.3u l=0.06u
MI27 net3 net27 net82 VSS nch w=0.3u l=0.06u
MI5 net27 net9 net85 VSS nch w=0.3u l=0.06u
MI16 net85 net9 net30 VSS nch w=0.3u l=0.06u
MI4 net30 net9 VSS VSS nch w=0.3u l=0.06u
MI2-M_u2 Z net3 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI32 net24 net27 VDD VDD pch w=0.3u l=0.06u
MI33 net82 net27 net24 VDD pch w=0.3u l=0.06u
MI34 net3 net27 net82 VDD pch w=0.3u l=0.06u
MI30 net85 net9 net31 VDD pch w=0.3u l=0.06u
MI31 net27 net9 net85 VDD pch w=0.3u l=0.06u
MI24 net31 net9 VDD VDD pch w=0.3u l=0.06u
MI2-M_u3 Z net3 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL1 I Z VDD VSS
MI2-M_u2 Z net3 VSS VSS nch w=0.3u l=0.06u
MU7-M_u2 net3 net5 VSS VSS nch w=0.39u l=0.98u
MU5-M_u2 net5 net9 VSS VSS nch w=0.39u l=0.98u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 Z net3 VDD VDD pch w=0.52u l=0.06u
MU7-M_u3 net3 net5 VDD VDD pch w=0.52u l=0.98u
MU5-M_u3 net5 net9 VDD VDD pch w=0.52u l=0.98u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL2 I Z VDD VSS
MI3-M_u2 net010 net016 VSS VSS nch w=0.29u l=0.785u
MI4-M_u2 net016 net3 VSS VSS nch w=0.29u l=0.785u
MI2-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
MU7-M_u2 net3 net5 VSS VSS nch w=0.39u l=0.785u
MU5-M_u2 net5 net9 VSS VSS nch w=0.39u l=0.785u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 net010 net016 VDD VDD pch w=0.52u l=0.785u
MI4-M_u3 net016 net3 VDD VDD pch w=0.52u l=0.785u
MI2-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
MU7-M_u3 net3 net5 VDD VDD pch w=0.52u l=0.785u
MU5-M_u3 net5 net9 VDD VDD pch w=0.52u l=0.785u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL3 I Z VDD VSS
MI3-M_u2 net010 net08 VSS VSS nch w=0.29u l=0.95u
MI4-M_u2 net08 net3 VSS VSS nch w=0.29u l=0.95u
MI2-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
MU7-M_u2 net3 net5 VSS VSS nch w=0.39u l=0.95u
MU5-M_u2 net5 net9 VSS VSS nch w=0.39u l=0.95u
MI1-M_u2 net9 I VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 net010 net08 VDD VDD pch w=0.52u l=0.95u
MI4-M_u3 net08 net3 VDD VDD pch w=0.52u l=0.95u
MI2-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
MU7-M_u3 net3 net5 VDD VDD pch w=0.52u l=0.95u
MU5-M_u3 net5 net9 VDD VDD pch w=0.52u l=0.95u
MI1-M_u3 net9 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DEL4 I Z VDD VSS
MI3-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 net010 net08 VSS VSS nch w=0.3u l=1u
MI8-M_u2 net08 net12 VSS VSS nch w=0.3u l=1u
MI4-M_u2 net12 net10 VSS VSS nch w=0.3u l=1u
MI5-M_u2 net10 net8 VSS VSS nch w=0.3u l=1u
MI6-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 net010 net08 VDD VDD pch w=0.3u l=1u
MI8-M_u3 net08 net12 VDD VDD pch w=0.3u l=1u
MI4-M_u3 net12 net10 VDD VDD pch w=0.3u l=1u
MI5-M_u3 net10 net8 VDD VDD pch w=0.3u l=1u
MI6-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFCND1 D CP CDN Q QN VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI18 net101 INCPB d2 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI21-M_u4 XI21-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI21-M_u3 d3 d2 XI21-net6 VSS nch w=0.39u l=0.06u
MI22-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 net101 d3 VSS VSS nch w=0.195u l=0.06u
MI21-M_u2 d3 CDN VDD VDD pch w=0.365u l=0.06u
MI21-M_u1 d3 d2 VDD VDD pch w=0.365u l=0.06u
MI22-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.22u l=0.06u
MI14-M_u3 net101 d3 VDD VDD pch w=0.26u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.245u l=0.06u
MI17 net101 INCP d2 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCND2 D CP CDN Q QN VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI18 net101 INCPB d2 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI30-M_u4 XI30-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI30-M_u3 d3 d2 XI30-net6 VSS nch w=0.21u l=0.06u
MI28-M_u4 XI28-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI28-M_u3 d3 d2 XI28-net6 VSS nch w=0.21u l=0.06u
MI22-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 net101 d3 VSS VSS nch w=0.21u l=0.06u
MI30-M_u2 d3 CDN VDD VDD pch w=0.4u l=0.06u
MI30-M_u1 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI28-M_u2 d3 CDN VDD VDD pch w=0.4u l=0.06u
MI28-M_u1 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI22-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.22u l=0.06u
MI14-M_u3 net101 d3 VDD VDD pch w=0.4u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.245u l=0.06u
MI17 net101 INCP d2 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCND4 D CP CDN Q QN VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI18 net101 INCPB d2 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI36-M_u4 XI36-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI36-M_u3 d3 d2 XI36-net6 VSS nch w=0.21u l=0.06u
MI30-M_u4 XI30-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI30-M_u3 d3 d2 XI30-net6 VSS nch w=0.21u l=0.06u
MI22-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI39-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 net101 d3 VSS VSS nch w=0.21u l=0.06u
MI36-M_u2 d3 CDN VDD VDD pch w=0.4u l=0.06u
MI36-M_u1 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI30-M_u2 d3 CDN VDD VDD pch w=0.4u l=0.06u
MI30-M_u1 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.245u l=0.06u
MI17 net101 INCP d2 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
MI22-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.22u l=0.06u
MI14-M_u3 net101 d3 VDD VDD pch w=0.4u l=0.06u
.ends
.subckt DFCNQD1 D CP CDN Q VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.16u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI29 d2 INCPB net050 VSS nch w=0.15u l=0.06u
MI26 net050 d3 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI21-M_u4 XI21-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI21-M_u3 d3 d2 XI21-net6 VSS nch w=0.39u l=0.06u
MI22-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.16u l=0.06u
MI21-M_u2 d3 CDN VDD VDD pch w=0.4u l=0.06u
MI21-M_u1 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI22-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.22u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI28 d2 INCP net086 VDD pch w=0.15u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI24 net086 d3 VDD VDD pch w=0.15u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.245u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCNQD2 D CP CDN Q VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.17u l=0.06u
MI26 net055 d3 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net055 VSS nch w=0.15u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI30-M_u4 XI30-net6 CDN VSS VSS nch w=0.19u l=0.06u
MI30-M_u3 d3 d2 XI30-net6 VSS nch w=0.19u l=0.06u
MI28-M_u4 XI28-net6 CDN VSS VSS nch w=0.19u l=0.06u
MI28-M_u3 d3 d2 XI28-net6 VSS nch w=0.19u l=0.06u
MI22-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI30-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI30-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
MI28-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI28-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
MI22-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.15u l=0.06u
MI32 d2 INCP net099 VDD pch w=0.15u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI33 net099 d3 VDD VDD pch w=0.15u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.37u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCNQD4 D CP CDN Q VDD VSS
MI4 net52 INCPB VSS VSS nch w=0.35u l=0.06u
MI15 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI5 d0 D net52 VSS nch w=0.35u l=0.06u
MI29 d2 INCPB net064 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI26 net064 d3 VSS VSS nch w=0.15u l=0.06u
MI36-M_u4 XI36-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI36-M_u3 d3 d2 XI36-net6 VSS nch w=0.21u l=0.06u
MI30-M_u4 XI30-net6 CDN VSS VSS nch w=0.21u l=0.06u
MI30-M_u3 d3 d2 XI30-net6 VSS nch w=0.21u l=0.06u
MI22-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI36-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI36-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
MI30-M_u2 d3 CDN VDD VDD pch w=0.44u l=0.06u
MI30-M_u1 d3 d2 VDD VDD pch w=0.44u l=0.06u
MI6 d0 D net85 VDD pch w=0.46u l=0.06u
MI7 net85 INCP VDD VDD pch w=0.46u l=0.06u
MI16 d1 INCPB d2 VDD pch w=0.27u l=0.06u
MI38 net091 d3 VDD VDD pch w=0.15u l=0.06u
MI28 d2 INCP net091 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
MI22-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.22u l=0.06u
.ends
.subckt DFCSND1 D CP CDN SDN Q QN VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI75-M_u4 XI75-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI75-M_u3 d3 d2 XI75-net6 VSS nch w=0.39u l=0.06u
MI74-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI75-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI75-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCSND2 D CP CDN SDN Q QN VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI80-M_u4 XI80-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI80-M_u3 d3 d2 XI80-net6 VSS nch w=0.39u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI79-M_u4 XI79-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI79-M_u3 d3 d2 XI79-net6 VSS nch w=0.39u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI78-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI76-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI80-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI79-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI79-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI78-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI76-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCSND4 D CP CDN SDN Q QN VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI89-M_u4 XI89-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI89-M_u3 d3 d2 XI89-net6 VSS nch w=0.39u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI88-M_u4 XI88-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI88-M_u3 d3 d2 XI88-net6 VSS nch w=0.39u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI87-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI86-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI78-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI79-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI81-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI89-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI89-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI88-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI88-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI87-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI86-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI78-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI79-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI80-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI81-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCSNQD1 D CP CDN SDN Q VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 net058 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI75-M_u4 XI75-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI75-M_u3 d3 d2 XI75-net6 VSS nch w=0.39u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 net058 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI73-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI75-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI75-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI71-M_u2 net058 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 net058 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI73-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 net058 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCSNQD2 D CP CDN SDN Q VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 net072 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI81-M_u4 XI81-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI81-M_u3 d3 d2 XI81-net6 VSS nch w=0.39u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 net072 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI80-M_u4 XI80-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI80-M_u3 d3 d2 XI80-net6 VSS nch w=0.39u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI79-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI76-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI81-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI81-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI71-M_u2 net072 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 net072 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI80-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI80-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI79-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI76-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 net072 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFCSNQD4 D CP CDN SDN Q VDD VSS
MI19 net48 INCPB VSS VSS nch w=0.305u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.23u l=0.06u
MI21 d0 D net48 VSS nch w=0.39u l=0.06u
MI22 net083 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI80-M_u4 XI80-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI80-M_u3 d3 d2 XI80-net6 VSS nch w=0.39u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 net083 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.21u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.21u l=0.06u
MI86-M_u4 XI86-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI86-M_u3 d3 d2 XI86-net6 VSS nch w=0.39u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI75-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI76-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI85-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI84-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI80-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI80-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI71-M_u2 net083 d3 VDD VDD pch w=0.35u l=0.06u
MI71-M_u1 net083 SDN VDD VDD pch w=0.35u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.48u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.48u l=0.06u
MI86-M_u2 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI86-M_u1 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.495u l=0.06u
MI28 net78 INCP VDD VDD pch w=0.495u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.28u l=0.06u
MI33 net083 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net92 VDD pch w=0.18u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI75-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI76-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI85-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI84-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFD1 D CP Q QN VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI5 net072 D net43 VSS nch w=0.37u l=0.06u
MI47 net072 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 net051 VSS VSS nch w=0.15u l=0.06u
MI55 net053 INCPB net055 VSS nch w=0.15u l=0.06u
MI50 net051 INCP net055 VSS nch w=0.2u l=0.06u
MI57-M_u2 net053 net068 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.18u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net053 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net068 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net068 net055 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net051 net072 VSS VSS nch w=0.39u l=0.06u
MI57-M_u3 net053 net068 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net053 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net068 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net068 net055 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net051 net072 VDD VDD pch w=0.52u l=0.06u
MI6 net072 D net74 VDD pch w=0.46u l=0.06u
MI7 net74 INCP VDD VDD pch w=0.46u l=0.06u
MI52 net051 INCPB net055 VDD pch w=0.215u l=0.06u
MI54 net053 INCP net055 VDD pch w=0.15u l=0.06u
MI45 net072 INCPB net86 VDD pch w=0.15u l=0.06u
MI43 net86 net051 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFD2 D CP Q QN VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI5 d0 D net43 VSS nch w=0.37u l=0.06u
MI47 d0 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI55 net53 INCPB d2 VSS nch w=0.15u l=0.06u
MI50 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.18u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29_0-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI29_1-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI27_0-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_1-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net53 d3 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29_0-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI29_1-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI27_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net53 d3 VDD VDD pch w=0.52u l=0.06u
MI6 d0 D net66 VDD pch w=0.46u l=0.06u
MI7 net66 INCP VDD VDD pch w=0.46u l=0.06u
MI52 d1 INCPB d2 VDD pch w=0.215u l=0.06u
MI54 net53 INCP d2 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFD4 D CP Q QN VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI5 d0 D net43 VSS nch w=0.37u l=0.06u
MI47 d0 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI55 net53 INCPB d2 VSS nch w=0.15u l=0.06u
MI50 d1 INCP d2 VSS nch w=0.2u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI29_0-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI29_1-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI29_2-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI29_3-M_u2 QN net53 VSS VSS nch w=0.39u l=0.06u
MI27_0-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_1-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_2-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_3-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net53 d3 VSS VSS nch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI29_0-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI29_1-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI29_2-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI29_3-M_u3 QN net53 VDD VDD pch w=0.52u l=0.06u
MI27_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net53 d3 VDD VDD pch w=0.84u l=0.06u
MI6 d0 D net66 VDD pch w=0.46u l=0.06u
MI7 net66 INCP VDD VDD pch w=0.46u l=0.06u
MI52 d1 INCPB d2 VDD pch w=0.215u l=0.06u
MI54 net53 INCP d2 VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFKCND1 D CP CN Q QN VDD VSS
MI15 net38 CN VSS VSS nch w=0.39u l=0.06u
MI12 net64 INCPB net39 VSS nch w=0.205u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.185u l=0.06u
MI16 net39 D net38 VSS nch w=0.39u l=0.06u
MI22-M_u2 net51 net88 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net88 net47 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.305u l=0.06u
MI22-M_u3 net51 net88 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net88 net47 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI17 VDD D net62 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net62 INCP net64 VDD pch w=0.29u l=0.06u
MI19 VDD CN net62 VDD pch w=0.52u l=0.06u
.ends
.subckt DFKCND2 D CP CN Q QN VDD VSS
MI15 net38 CN VSS VSS nch w=0.39u l=0.06u
MI12 net64 INCPB net48 VSS nch w=0.205u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.185u l=0.06u
MI16 net48 D net38 VSS nch w=0.39u l=0.06u
MI21-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI22-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net88 net47 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.305u l=0.06u
MI14-M_u2 net51 net88 VSS VSS nch w=0.39u l=0.06u
MI21-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI22-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net88 net47 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net51 net88 VDD VDD pch w=0.52u l=0.06u
MI17 VDD D net39 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net39 INCP net64 VDD pch w=0.29u l=0.06u
MI19 VDD CN net39 VDD pch w=0.52u l=0.06u
.ends
.subckt DFKCND4 D CP CN Q QN VDD VSS
MI15 net38 CN VSS VSS nch w=0.39u l=0.06u
MI12 net64 INCPB net85 VSS nch w=0.205u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.185u l=0.06u
MI16 net85 D net38 VSS nch w=0.39u l=0.06u
MI30-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI21-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53_0-M_u2 net88 net47 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 net88 net47 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.28u l=0.06u
MI14-M_u2 net51 net88 VSS VSS nch w=0.78u l=0.06u
MI25-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI17 VDD D net39 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net39 INCP net64 VDD pch w=0.29u l=0.06u
MI19 VDD CN net39 VDD pch w=0.52u l=0.06u
MI30-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI21-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53_0-M_u3 net88 net47 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 net88 net47 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net51 net88 VDD VDD pch w=1.04u l=0.06u
MI25-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFKCNQD1 D CP CN Q VDD VSS
MI15 net38 CN VSS VSS nch w=0.21u l=0.06u
MI12 net64 INCPB net39 VSS nch w=0.15u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.225u l=0.06u
MI16 net39 D net38 VSS nch w=0.21u l=0.06u
MI21 net046 net88 VSS VSS nch w=0.15u l=0.06u
MI49 net47 INCPB net046 VSS nch w=0.15u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net88 net47 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.325u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net88 net47 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI17 VDD D net62 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net62 INCP net64 VDD pch w=0.335u l=0.06u
MI51 net084 net88 VDD VDD pch w=0.15u l=0.06u
MI19 VDD CN net62 VDD pch w=0.52u l=0.06u
MI22 net47 INCP net084 VDD pch w=0.15u l=0.06u
.ends
.subckt DFKCNQD2 D CP CN Q VDD VSS
MI26 net48 net88 VSS VSS nch w=0.15u l=0.06u
MI15 net38 CN VSS VSS nch w=0.21u l=0.06u
MI12 net64 INCPB net39 VSS nch w=0.15u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.225u l=0.06u
MI16 net39 D net38 VSS nch w=0.21u l=0.06u
MI29 net47 INCPB net48 VSS nch w=0.15u l=0.06u
MI21-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net88 net47 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.325u l=0.06u
MI21-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net88 net47 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI17 VDD D net62 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net62 INCP net64 VDD pch w=0.335u l=0.06u
MI28 net47 INCP net84 VDD pch w=0.15u l=0.06u
MI24 net84 net88 VDD VDD pch w=0.15u l=0.06u
MI19 VDD CN net62 VDD pch w=0.52u l=0.06u
.ends
.subckt DFKCNQD4 D CP CN Q VDD VSS
MI26 net48 net88 VSS VSS nch w=0.15u l=0.06u
MI15 net38 CN VSS VSS nch w=0.21u l=0.06u
MI12 net64 INCPB net39 VSS nch w=0.15u l=0.06u
MI47 net64 INCP net54 VSS nch w=0.15u l=0.06u
MI48 net54 net55 VSS VSS nch w=0.15u l=0.06u
MI50 net55 INCP net130 VSS nch w=0.225u l=0.06u
MI16 net39 D net38 VSS nch w=0.21u l=0.06u
MI29 net130 INCPB net48 VSS nch w=0.15u l=0.06u
MI22-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI21-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net88 VSS VSS nch w=0.39u l=0.06u
MI53_0-M_u2 net88 net130 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 net88 net130 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.325u l=0.06u
MI17 VDD D net62 VDD pch w=0.52u l=0.06u
MI52 net55 INCPB net130 VDD pch w=0.45u l=0.06u
MI45 net64 INCPB net73 VDD pch w=0.15u l=0.06u
MI43 net73 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net62 INCP net64 VDD pch w=0.335u l=0.06u
MI28 net130 INCP net84 VDD pch w=0.15u l=0.06u
MI24 net84 net88 VDD VDD pch w=0.15u l=0.06u
MI19 VDD CN net62 VDD pch w=0.52u l=0.06u
MI22-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI21-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net88 VDD VDD pch w=0.52u l=0.06u
MI53_0-M_u3 net88 net130 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 net88 net130 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
.ends
.subckt DFKCSND1 D CP CN SN Q QN VDD VSS
MI15 net44 CN VSS VSS nch w=0.22u l=0.06u
MI12 net47 INCPB net46 VSS nch w=0.205u l=0.06u
MI47 net47 INCP net53 VSS nch w=0.15u l=0.06u
MI48 net53 net54 VSS VSS nch w=0.15u l=0.06u
MI55 net56 INCPB net58 VSS nch w=0.15u l=0.06u
MI50 net54 INCP net58 VSS nch w=0.2u l=0.06u
MI17 net46 net105 net44 VSS nch w=0.15u l=0.06u
MI16 net46 D net44 VSS nch w=0.15u l=0.06u
MI25-M_u2 net56 net99 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI24-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net99 net58 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net54 net47 VSS VSS nch w=0.295u l=0.06u
MI22-M_u2 net105 SN VSS VSS nch w=0.205u l=0.06u
MI25-M_u3 net56 net99 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI24-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net99 net58 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net54 net47 VDD VDD pch w=0.27u l=0.06u
MI22-M_u3 net105 SN VDD VDD pch w=0.3u l=0.06u
MI52 net54 INCPB net58 VDD pch w=0.45u l=0.06u
MI54 net56 INCP net58 VDD pch w=0.15u l=0.06u
MI45 net47 INCPB net76 VDD pch w=0.15u l=0.06u
MI43 net76 net54 VDD VDD pch w=0.15u l=0.06u
MI18 net84 D net81 VDD pch w=0.3u l=0.06u
MI20 VDD net105 net84 VDD pch w=0.3u l=0.06u
MI19 net81 INCP net47 VDD pch w=0.29u l=0.06u
MI21 VDD CN net81 VDD pch w=0.3u l=0.06u
.ends
.subckt DFKCSND2 D CP CN SN Q QN VDD VSS
MI15 net44 CN VSS VSS nch w=0.22u l=0.06u
MI12 net47 INCPB net46 VSS nch w=0.235u l=0.06u
MI47 net47 INCP net53 VSS nch w=0.15u l=0.06u
MI48 net53 net54 VSS VSS nch w=0.15u l=0.06u
MI55 net56 INCPB net58 VSS nch w=0.15u l=0.06u
MI50 net54 INCP net58 VSS nch w=0.185u l=0.06u
MI17 net46 net105 net44 VSS nch w=0.15u l=0.06u
MI16 net46 D net44 VSS nch w=0.15u l=0.06u
MI25-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI24-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net99 net58 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net54 net47 VSS VSS nch w=0.28u l=0.06u
MI14-M_u2 net56 net99 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net105 SN VSS VSS nch w=0.205u l=0.06u
MI25-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI24-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net99 net58 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net54 net47 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net56 net99 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net105 SN VDD VDD pch w=0.25u l=0.06u
MI52 net54 INCPB net58 VDD pch w=0.45u l=0.06u
MI54 net56 INCP net58 VDD pch w=0.15u l=0.06u
MI45 net47 INCPB net76 VDD pch w=0.15u l=0.06u
MI43 net76 net54 VDD VDD pch w=0.15u l=0.06u
MI18 net84 D net81 VDD pch w=0.25u l=0.06u
MI20 VDD net105 net84 VDD pch w=0.25u l=0.06u
MI19 net81 INCP net47 VDD pch w=0.27u l=0.06u
MI21 VDD CN net81 VDD pch w=0.25u l=0.06u
.ends
.subckt DFKCSND4 D CP CN SN Q QN VDD VSS
MI15 net44 CN VSS VSS nch w=0.22u l=0.06u
MI12 net47 INCPB net46 VSS nch w=0.235u l=0.06u
MI47 net47 INCP net53 VSS nch w=0.15u l=0.06u
MI48 net53 net54 VSS VSS nch w=0.15u l=0.06u
MI55 net56 INCPB net87 VSS nch w=0.15u l=0.06u
MI50 net54 INCP net87 VSS nch w=0.2u l=0.06u
MI17 net46 net105 net44 VSS nch w=0.15u l=0.06u
MI16 net46 D net44 VSS nch w=0.15u l=0.06u
MI28-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI34-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI33-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net99 VSS VSS nch w=0.39u l=0.06u
MI53_0-M_u2 net99 net87 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 net99 net87 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net54 net47 VSS VSS nch w=0.295u l=0.06u
MI14-M_u2 net56 net99 VSS VSS nch w=0.78u l=0.06u
MI35-M_u2 QN net56 VSS VSS nch w=0.39u l=0.06u
MI22-M_u2 net105 SN VSS VSS nch w=0.205u l=0.06u
MI52 net54 INCPB net87 VDD pch w=0.45u l=0.06u
MI54 net56 INCP net87 VDD pch w=0.15u l=0.06u
MI45 net47 INCPB net76 VDD pch w=0.15u l=0.06u
MI43 net76 net54 VDD VDD pch w=0.15u l=0.06u
MI18 net84 D net81 VDD pch w=0.3u l=0.06u
MI20 VDD net105 net84 VDD pch w=0.3u l=0.06u
MI19 net81 INCP net47 VDD pch w=0.27u l=0.06u
MI21 VDD CN net81 VDD pch w=0.3u l=0.06u
MI28-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI34-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI33-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net99 VDD VDD pch w=0.52u l=0.06u
MI53_0-M_u3 net99 net87 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 net99 net87 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net54 net47 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net56 net99 VDD VDD pch w=1.04u l=0.06u
MI35-M_u3 QN net56 VDD VDD pch w=0.52u l=0.06u
MI22-M_u3 net105 SN VDD VDD pch w=0.3u l=0.06u
.ends
.subckt DFKSND1 D CP SN Q QN VDD VSS
MI15 net44 D VSS VSS nch w=0.22u l=0.06u
MI12 net64 INCPB net44 VSS nch w=0.205u l=0.06u
MI47 net64 INCP net56 VSS nch w=0.15u l=0.06u
MI48 net56 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.185u l=0.06u
MI16 net44 net84 VSS VSS nch w=0.22u l=0.06u
MI22-M_u2 net51 net90 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net90 net47 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.305u l=0.06u
MI20-M_u2 net84 SN VSS VSS nch w=0.195u l=0.06u
MI22-M_u3 net51 net90 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net90 net47 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI20-M_u3 net84 SN VDD VDD pch w=0.26u l=0.06u
MI17 net61 D net44 VDD pch w=0.4u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net68 VDD pch w=0.15u l=0.06u
MI43 net68 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net44 INCP net64 VDD pch w=0.375u l=0.06u
MI19 VDD net84 net61 VDD pch w=0.4u l=0.06u
.ends
.subckt DFKSND2 D CP SN Q QN VDD VSS
MI15 net44 D VSS VSS nch w=0.22u l=0.06u
MI12 net64 INCPB net44 VSS nch w=0.22u l=0.06u
MI47 net64 INCP net56 VSS nch w=0.15u l=0.06u
MI48 net56 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.19u l=0.06u
MI16 net44 net84 VSS VSS nch w=0.22u l=0.06u
MI22-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net90 net47 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.295u l=0.06u
MI14-M_u2 net51 net90 VSS VSS nch w=0.39u l=0.06u
MI20-M_u2 net84 SN VSS VSS nch w=0.195u l=0.06u
MI22-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net90 net47 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net51 net90 VDD VDD pch w=0.52u l=0.06u
MI20-M_u3 net84 SN VDD VDD pch w=0.26u l=0.06u
MI17 net61 D net44 VDD pch w=0.4u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net68 VDD pch w=0.15u l=0.06u
MI43 net68 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net44 INCP net64 VDD pch w=0.375u l=0.06u
MI19 VDD net84 net61 VDD pch w=0.4u l=0.06u
.ends
.subckt DFKSND4 D CP SN Q QN VDD VSS
MI15 net44 D VSS VSS nch w=0.22u l=0.06u
MI12 net64 INCPB net44 VSS nch w=0.205u l=0.06u
MI47 net64 INCP net56 VSS nch w=0.15u l=0.06u
MI48 net56 net55 VSS VSS nch w=0.15u l=0.06u
MI55 net51 INCPB net47 VSS nch w=0.15u l=0.06u
MI50 net55 INCP net47 VSS nch w=0.19u l=0.06u
MI16 net44 net84 VSS VSS nch w=0.22u l=0.06u
MI22-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net51 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net90 net47 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net55 net64 VSS VSS nch w=0.295u l=0.06u
MI14-M_u2 net51 net90 VSS VSS nch w=0.78u l=0.06u
MI20-M_u2 net84 SN VSS VSS nch w=0.195u l=0.06u
MI22-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net51 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net90 net47 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net55 net64 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net51 net90 VDD VDD pch w=1.04u l=0.06u
MI20-M_u3 net84 SN VDD VDD pch w=0.26u l=0.06u
MI17 net61 D net44 VDD pch w=0.4u l=0.06u
MI52 net55 INCPB net47 VDD pch w=0.45u l=0.06u
MI54 net51 INCP net47 VDD pch w=0.15u l=0.06u
MI45 net64 INCPB net68 VDD pch w=0.15u l=0.06u
MI43 net68 net55 VDD VDD pch w=0.15u l=0.06u
MI18 net44 INCP net64 VDD pch w=0.375u l=0.06u
MI19 VDD net84 net61 VDD pch w=0.4u l=0.06u
.ends
.subckt DFNCND1 D CPN CDN Q QN VDD VSS
MI4 net52 net66 VSS VSS nch w=0.16u l=0.06u
MI15 d1 INCPB net37 VSS nch w=0.17u l=0.06u
MI5 d0 D net52 VSS nch w=0.16u l=0.06u
MI18 d3 net66 net37 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI60-M_u4 XI60-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI60-M_u3 d2 net37 XI60-net6 VSS nch w=0.39u l=0.06u
MI63-M_u2 d3 d2 VSS VSS nch w=0.195u l=0.06u
MI62-M_u2 net66 INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI60-M_u2 d2 CDN VDD VDD pch w=0.375u l=0.06u
MI60-M_u1 d2 net37 VDD VDD pch w=0.375u l=0.06u
MI63-M_u3 d3 d2 VDD VDD pch w=0.26u l=0.06u
MI62-M_u3 net66 INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.305u l=0.06u
MI6 d0 D net85 VDD pch w=0.45u l=0.06u
MI7 net85 INCPB VDD VDD pch w=0.45u l=0.06u
MI16 d1 net66 net37 VDD pch w=0.27u l=0.06u
MI17 d3 INCPB net37 VDD pch w=0.15u l=0.06u
MI45 d0 net66 net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNCND2 D CPN CDN Q QN VDD VSS
MI4 net52 net66 VSS VSS nch w=0.16u l=0.06u
MI15 d1 INCPB net37 VSS nch w=0.17u l=0.06u
MI5 d0 D net52 VSS nch w=0.16u l=0.06u
MI18 d3 net66 net37 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI64-M_u4 XI64-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI64-M_u3 d2 net37 XI64-net6 VSS nch w=0.23u l=0.06u
MI63-M_u4 XI63-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI63-M_u3 d2 net37 XI63-net6 VSS nch w=0.23u l=0.06u
MI61-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI62-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI65-M_u2 net66 INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 d3 d2 VSS VSS nch w=0.21u l=0.06u
MI64-M_u2 d2 CDN VDD VDD pch w=0.52u l=0.06u
MI64-M_u1 d2 net37 VDD VDD pch w=0.52u l=0.06u
MI63-M_u2 d2 CDN VDD VDD pch w=0.375u l=0.06u
MI63-M_u1 d2 net37 VDD VDD pch w=0.375u l=0.06u
MI61-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI62-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI65-M_u3 net66 INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.305u l=0.06u
MI14-M_u3 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI6 d0 D net85 VDD pch w=0.45u l=0.06u
MI7 net85 INCPB VDD VDD pch w=0.45u l=0.06u
MI16 d1 net66 net37 VDD pch w=0.27u l=0.06u
MI17 d3 INCPB net37 VDD pch w=0.15u l=0.06u
MI45 d0 net66 net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNCND4 D CPN CDN Q QN VDD VSS
MI4 net52 net66 VSS VSS nch w=0.16u l=0.06u
MI15 d1 INCPB net37 VSS nch w=0.17u l=0.06u
MI5 d0 D net52 VSS nch w=0.16u l=0.06u
MI18 d3 net66 net37 VSS nch w=0.15u l=0.06u
MI47 d0 INCPB net59 VSS nch w=0.15u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.15u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.15u l=0.06u
MI60-M_u4 XI60-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI60-M_u3 d2 net37 XI60-net6 VSS nch w=0.23u l=0.06u
MI67-M_u4 XI67-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI67-M_u3 d2 net37 XI67-net6 VSS nch w=0.23u l=0.06u
MI61-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI62-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI63-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI64-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI65-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI66-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net66 INCPB VSS VSS nch w=0.39u l=0.06u
MI69-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 d3 d2 VSS VSS nch w=0.42u l=0.06u
MI60-M_u2 d2 CDN VDD VDD pch w=0.52u l=0.06u
MI60-M_u1 d2 net37 VDD VDD pch w=0.52u l=0.06u
MI67-M_u2 d2 CDN VDD VDD pch w=0.375u l=0.06u
MI67-M_u1 d2 net37 VDD VDD pch w=0.375u l=0.06u
MI6 d0 D net85 VDD pch w=0.45u l=0.06u
MI7 net85 INCPB VDD VDD pch w=0.45u l=0.06u
MI16 d1 net66 net37 VDD pch w=0.27u l=0.06u
MI17 d3 INCPB net37 VDD pch w=0.15u l=0.06u
MI45 d0 net66 net98 VDD pch w=0.15u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.15u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.15u l=0.06u
MI61-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI62-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI63-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI64-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI65-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI66-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net66 INCPB VDD VDD pch w=0.52u l=0.06u
MI69-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.305u l=0.06u
MI14-M_u3 d3 d2 VDD VDD pch w=0.92u l=0.06u
.ends
.subckt DFNCSND1 D CPN CDN SDN Q QN VDD VSS
MI19 net48 net76 VSS VSS nch w=0.37u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.2u l=0.06u
MI21 d0 D net48 VSS nch w=0.37u l=0.06u
MI22 d4 net76 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.21u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.21u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.2u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.2u l=0.06u
MI73-M_u4 XI73-net6 CDN VSS VSS nch w=0.205u l=0.06u
MI73-M_u3 d3 d2 XI73-net6 VSS nch w=0.205u l=0.06u
MI74-M_u2 net76 INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.385u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.385u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI73-M_u2 d3 CDN VDD VDD pch w=0.345u l=0.06u
MI73-M_u1 d3 d2 VDD VDD pch w=0.345u l=0.06u
MI74-M_u3 net76 INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.48u l=0.06u
MI28 net78 INCPB VDD VDD pch w=0.48u l=0.06u
MI30 d1 net76 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net76 net92 VDD pch w=0.15u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNCSND2 D CPN CDN SDN Q QN VDD VSS
MI19 net48 net76 VSS VSS nch w=0.37u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.2u l=0.06u
MI21 d0 D net48 VSS nch w=0.37u l=0.06u
MI22 d4 net76 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI77-M_u4 XI77-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI77-M_u3 d3 d2 XI77-net6 VSS nch w=0.23u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.23u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.23u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.2u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.2u l=0.06u
MI76-M_u4 XI76-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI76-M_u3 d3 d2 XI76-net6 VSS nch w=0.23u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI78-M_u2 net76 INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI77-M_u2 d3 CDN VDD VDD pch w=0.49u l=0.06u
MI77-M_u1 d3 d2 VDD VDD pch w=0.49u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI76-M_u2 d3 CDN VDD VDD pch w=0.49u l=0.06u
MI76-M_u1 d3 d2 VDD VDD pch w=0.49u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI78-M_u3 net76 INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net78 VDD pch w=0.48u l=0.06u
MI28 net78 INCPB VDD VDD pch w=0.48u l=0.06u
MI30 d1 net76 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net76 net92 VDD pch w=0.15u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNCSND4 D CPN CDN SDN Q QN VDD VSS
MI19 net48 net76 VSS VSS nch w=0.37u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.2u l=0.06u
MI21 d0 D net48 VSS nch w=0.37u l=0.06u
MI22 d4 net76 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net60 VSS nch w=0.15u l=0.06u
MI24 net60 d1 net57 VSS nch w=0.15u l=0.06u
MI25 net57 CDN VSS VSS nch w=0.15u l=0.06u
MI82-M_u4 XI82-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI82-M_u3 d3 d2 XI82-net6 VSS nch w=0.23u l=0.06u
MI71-M_u4 XI71-net6 d3 VSS VSS nch w=0.23u l=0.06u
MI71-M_u3 d4 SDN XI71-net6 VSS nch w=0.23u l=0.06u
MI72-M_u4 XI72-net6 d0 VSS VSS nch w=0.2u l=0.06u
MI72-M_u3 d1 SDN XI72-net6 VSS nch w=0.2u l=0.06u
MI81-M_u4 XI81-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI81-M_u3 d3 d2 XI81-net6 VSS nch w=0.23u l=0.06u
MI73-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI75-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI76-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI77-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI78-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI79-M_u2 net76 INCPB VSS VSS nch w=0.39u l=0.06u
MI84-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 d3 CDN VDD VDD pch w=0.49u l=0.06u
MI82-M_u1 d3 d2 VDD VDD pch w=0.49u l=0.06u
MI71-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI71-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI72-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI72-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI81-M_u2 d3 CDN VDD VDD pch w=0.49u l=0.06u
MI81-M_u1 d3 d2 VDD VDD pch w=0.49u l=0.06u
MI26 d0 D net78 VDD pch w=0.48u l=0.06u
MI28 net78 INCPB VDD VDD pch w=0.48u l=0.06u
MI30 d1 net76 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net76 net92 VDD pch w=0.15u l=0.06u
MI35 net92 d1 VDD VDD pch w=0.15u l=0.06u
MI36 net92 CDN VDD VDD pch w=0.15u l=0.06u
MI73-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI75-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI76-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI77-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI78-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI79-M_u3 net76 INCPB VDD VDD pch w=0.52u l=0.06u
MI84-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFND1 D CPN Q QN VDD VSS
MI4 net43 net55 VSS VSS nch w=0.2u l=0.06u
MI5 d0 D net43 VSS nch w=0.2u l=0.06u
MI47 d0 INCPB net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI55 net67 net55 d2 VSS nch w=0.15u l=0.06u
MI50 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI56-M_u2 net67 d3 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 net55 INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI56-M_u3 net67 d3 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 net55 INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 d3 d2 VDD VDD pch w=0.5u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.27u l=0.06u
MI6 d0 D net66 VDD pch w=0.43u l=0.06u
MI7 net66 INCPB VDD VDD pch w=0.43u l=0.06u
MI52 d1 net55 d2 VDD pch w=0.27u l=0.06u
MI54 net67 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net55 net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFND2 D CPN Q QN VDD VSS
MI4 net43 net55 VSS VSS nch w=0.2u l=0.06u
MI5 d0 D net43 VSS nch w=0.2u l=0.06u
MI47 d0 INCPB net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI55 net67 net55 d2 VSS nch w=0.15u l=0.06u
MI50 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI56-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI58-M_u2 net55 INCPB VSS VSS nch w=0.195u l=0.06u
MI59-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 net67 d3 VSS VSS nch w=0.21u l=0.06u
MI56-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI58-M_u3 net55 INCPB VDD VDD pch w=0.26u l=0.06u
MI59-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net67 d3 VDD VDD pch w=0.52u l=0.06u
MI6 d0 D net66 VDD pch w=0.43u l=0.06u
MI7 net66 INCPB VDD VDD pch w=0.43u l=0.06u
MI52 d1 net55 d2 VDD pch w=0.27u l=0.06u
MI54 net67 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net55 net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFND4 D CPN Q QN VDD VSS
MI4 net43 net55 VSS VSS nch w=0.2u l=0.06u
MI5 d0 D net43 VSS nch w=0.2u l=0.06u
MI47 d0 INCPB net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI55 net67 net55 d2 VSS nch w=0.15u l=0.06u
MI50 d1 INCPB d2 VSS nch w=0.19u l=0.06u
MI56-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI58-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI59-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI61-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI63-M_u2 net55 INCPB VSS VSS nch w=0.39u l=0.06u
MI62-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net67 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI53_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI14-M_u2 net67 d3 VSS VSS nch w=0.42u l=0.06u
MI6 d0 D net66 VDD pch w=0.43u l=0.06u
MI7 net66 INCPB VDD VDD pch w=0.43u l=0.06u
MI52 d1 net55 d2 VDD pch w=0.27u l=0.06u
MI54 net67 INCPB d2 VDD pch w=0.15u l=0.06u
MI45 d0 net55 net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
MI56-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI58-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI59-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI61-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI63-M_u3 net55 INCPB VDD VDD pch w=0.52u l=0.06u
MI62-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net67 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI53_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.27u l=0.06u
MI14-M_u3 net67 d3 VDD VDD pch w=1.04u l=0.06u
.ends
.subckt DFNSND1 D CPN SDN Q QN VDD VSS
MI19 net57 net68 VSS VSS nch w=0.37u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.21u l=0.06u
MI21 d0 D net57 VSS nch w=0.37u l=0.06u
MI22 d4 net68 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI31-M_u3 d4 SDN XI31-net6 VSS nch w=0.2u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI40-M_u2 net68 INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI31-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI40-M_u3 net68 INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.44u l=0.06u
MI28 net82 INCPB VDD VDD pch w=0.44u l=0.06u
MI30 d1 net68 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net68 net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNSND2 D CPN SDN Q QN VDD VSS
MI19 net57 net68 VSS VSS nch w=0.23u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.21u l=0.06u
MI21 d0 D net57 VSS nch w=0.23u l=0.06u
MI22 d4 net68 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.2u l=0.06u
MI31-M_u3 d4 SDN XI31-net6 VSS nch w=0.2u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI36-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI41-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 net68 INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CPN VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI31-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI36-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 net68 INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CPN VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.46u l=0.06u
MI28 net82 INCPB VDD VDD pch w=0.46u l=0.06u
MI30 d1 net68 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net68 net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFNSND4 D CPN SDN Q QN VDD VSS
MI19 net57 net68 VSS VSS nch w=0.23u l=0.06u
MI20 d1 INCPB d2 VSS nch w=0.21u l=0.06u
MI21 d0 D net57 VSS nch w=0.23u l=0.06u
MI22 d4 net68 d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCPB net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u3 d4 SDN XI31-net6 VSS nch w=0.39u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI43-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI52-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI54-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI25_0-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI25_1-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI48-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI40-M_u2 net68 INCPB VSS VSS nch w=0.39u l=0.06u
MI55-M_u2 INCPB CPN VSS VSS nch w=0.39u l=0.06u
MI51-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 d4 d3 VDD VDD pch w=0.52u l=0.06u
MI31-M_u1 d4 SDN VDD VDD pch w=0.52u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.46u l=0.06u
MI28 net82 INCPB VDD VDD pch w=0.46u l=0.06u
MI30 d1 net68 d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCPB d2 VDD pch w=0.15u l=0.06u
MI34 d0 net68 net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
MI43-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI52-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI54-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI25_0-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI25_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI48-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI40-M_u3 net68 INCPB VDD VDD pch w=0.52u l=0.06u
MI55-M_u3 INCPB CPN VDD VDD pch w=0.52u l=0.06u
MI51-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFQD1 D CP Q VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI56 net039 net67 VSS VSS nch w=0.15u l=0.06u
MI5 d0 D net43 VSS nch w=0.37u l=0.06u
MI47 d0 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI49 d2 INCPB net039 VSS nch w=0.15u l=0.06u
MI50 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net67 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net67 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net67 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net67 d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI57 d2 INCP net069 VDD pch w=0.15u l=0.06u
MI6 d0 D net66 VDD pch w=0.46u l=0.06u
MI7 net66 INCP VDD VDD pch w=0.46u l=0.06u
MI52 d1 INCPB d2 VDD pch w=0.26u l=0.06u
MI51 net069 net67 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFQD2 D CP Q VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI5 d0 D net43 VSS nch w=0.37u l=0.06u
MI26 net94 d3 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net94 VSS nch w=0.15u l=0.06u
MI50 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI56-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27_0-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_1-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI56-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI6 d0 D net66 VDD pch w=0.46u l=0.06u
MI7 net66 INCP VDD VDD pch w=0.46u l=0.06u
MI52 d1 INCPB d2 VDD pch w=0.26u l=0.06u
MI28 d2 INCP net75 VDD pch w=0.15u l=0.06u
MI24 net75 d3 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFQD4 D CP Q VDD VSS
MI4 net43 INCPB VSS VSS nch w=0.37u l=0.06u
MI5 d0 D net43 VSS nch w=0.37u l=0.06u
MI26 net94 d3 VSS VSS nch w=0.15u l=0.06u
MI47 d0 INCP net50 VSS nch w=0.15u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.15u l=0.06u
MI29 d2 INCPB net94 VSS nch w=0.15u l=0.06u
MI50 d1 INCP d2 VSS nch w=0.19u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI27_0-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_1-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_2-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI27_3-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI56_0-M_u2 d3 d2 VSS VSS nch w=0.195u l=0.06u
MI56_1-M_u2 d3 d2 VSS VSS nch w=0.195u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI27_0-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_1-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_2-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI27_3-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI56_0-M_u3 d3 d2 VDD VDD pch w=0.26u l=0.06u
MI56_1-M_u3 d3 d2 VDD VDD pch w=0.26u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI6 d0 D net66 VDD pch w=0.46u l=0.06u
MI7 net66 INCP VDD VDD pch w=0.46u l=0.06u
MI52 d1 INCPB d2 VDD pch w=0.26u l=0.06u
MI28 d2 INCP net75 VDD pch w=0.15u l=0.06u
MI24 net75 d3 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net84 VDD pch w=0.15u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFSND1 D CP SDN Q QN VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.235u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI31-M_u3 d4 SDN XI31-net6 VSS nch w=0.195u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI57-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI31-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI57-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFSND2 D CP SDN Q QN VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.235u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 d4 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.195u l=0.06u
MI31-M_u3 d4 SDN XI31-net6 VSS nch w=0.195u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI36-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI43-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 QN d4 VSS VSS nch w=0.39u l=0.06u
MI41-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 d4 d3 VDD VDD pch w=0.26u l=0.06u
MI31-M_u1 d4 SDN VDD VDD pch w=0.26u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI36-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI43-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 QN d4 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 d4 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFSND4 D CP SDN Q QN VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.235u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 net124 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u3 net124 SDN XI31-net6 VSS nch w=0.39u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI36-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI39-M_u2 QN net124 VSS VSS nch w=0.39u l=0.06u
MI41-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI43-M_u2 QN net124 VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 QN net124 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI45-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN net124 VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 net124 d3 VDD VDD pch w=0.52u l=0.06u
MI31-M_u1 net124 SDN VDD VDD pch w=0.52u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 net124 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
MI36-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 QN net124 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI43-M_u3 QN net124 VDD VDD pch w=0.52u l=0.06u
MI44-M_u3 QN net124 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI45-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN net124 VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFSNQD1 D CP SDN Q VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.24u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 net054 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI31-M_u3 net054 SDN XI31-net6 VSS nch w=0.15u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.39u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 net054 d3 VDD VDD pch w=0.15u l=0.06u
MI31-M_u1 net054 SDN VDD VDD pch w=0.15u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 net054 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFSNQD2 D CP SDN Q VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.235u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 net061 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI31-M_u3 net061 SDN XI31-net6 VSS nch w=0.15u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI36-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI55-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 net061 d3 VDD VDD pch w=0.15u l=0.06u
MI31-M_u1 net061 SDN VDD VDD pch w=0.15u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI36-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI55-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 net061 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt DFSNQD4 D CP SDN Q VDD VSS
MI19 net57 INCPB VSS VSS nch w=0.31u l=0.06u
MI20 d1 INCP d2 VSS nch w=0.235u l=0.06u
MI21 d0 D net57 VSS nch w=0.39u l=0.06u
MI22 net124 INCPB d2 VSS nch w=0.15u l=0.06u
MI23 d0 INCP net44 VSS nch w=0.15u l=0.06u
MI24 net44 d1 VSS VSS nch w=0.15u l=0.06u
MI31-M_u4 XI31-net6 d3 VSS VSS nch w=0.15u l=0.06u
MI31-M_u3 net124 SDN XI31-net6 VSS nch w=0.15u l=0.06u
MI32-M_u4 XI32-net6 d0 VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 d1 SDN XI32-net6 VSS nch w=0.39u l=0.06u
MI36-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI41-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI42-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d3 d2 VSS VSS nch w=0.78u l=0.06u
MI40-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI45-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI60-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 net124 d3 VDD VDD pch w=0.15u l=0.06u
MI31-M_u1 net124 SDN VDD VDD pch w=0.15u l=0.06u
MI32-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI32-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
MI26 d0 D net82 VDD pch w=0.52u l=0.06u
MI28 net82 INCP VDD VDD pch w=0.52u l=0.06u
MI30 d1 INCPB d2 VDD pch w=0.32u l=0.06u
MI33 net124 INCP d2 VDD pch w=0.15u l=0.06u
MI34 d0 INCPB net65 VDD pch w=0.15u l=0.06u
MI35 net65 d1 VDD VDD pch w=0.15u l=0.06u
MI36-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI41-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI42-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d3 d2 VDD VDD pch w=1.04u l=0.06u
MI40-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI45-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI60-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt DFXD1 DA DB SA CP Q QN VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.28u l=0.06u
MI30 net53 DB VSS VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.2u l=0.06u
MI17 net72 INCPB net68 VSS nch w=0.15u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net57 net84 net53 VSS nch w=0.39u l=0.06u
MI44-M_u2 net72 net90 VSS VSS nch w=0.195u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.33u l=0.06u
MI22-M_u2 net90 net68 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI44-M_u3 net72 net90 VDD VDD pch w=0.26u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.34u l=0.06u
MI22-M_u3 net90 net68 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI21 net72 INCP net68 VDD pch w=0.15u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.48u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.34u l=0.06u
MI36 net108 net84 net110 VDD pch w=0.34u l=0.06u
MI37 net53 DB VDD VDD pch w=0.52u l=0.06u
MI38 net108 SA net53 VDD pch w=0.4u l=0.06u
MI39 net66 INCP net108 VDD pch w=0.315u l=0.06u
.ends
.subckt DFXD2 DA DB SA CP Q QN VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.31u l=0.06u
MI51 net57 net84 net108 VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.18u l=0.06u
MI17 net72 INCPB net68 VSS nch w=0.15u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net108 DB VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net72 net90 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.315u l=0.06u
MI22-M_u2 net90 net68 VSS VSS nch w=0.78u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI52-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI53-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI44-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net72 net90 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.3u l=0.06u
MI22-M_u3 net90 net68 VDD VDD pch w=1.04u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI52-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI53-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI50 net123 SA net108 VDD pch w=0.4u l=0.06u
MI21 net72 INCP net68 VDD pch w=0.15u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.48u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.34u l=0.06u
MI36 net123 net84 net110 VDD pch w=0.34u l=0.06u
MI38 net108 DB VDD VDD pch w=0.52u l=0.06u
MI39 net66 INCP net123 VDD pch w=0.24u l=0.06u
.ends
.subckt DFXD4 DA DB SA CP Q QN VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.31u l=0.06u
MI51 net57 net84 net108 VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.18u l=0.06u
MI17 net72 INCPB net68 VSS nch w=0.15u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net108 DB VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI49-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI54-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net72 net90 VSS VSS nch w=0.78u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.315u l=0.06u
MI22-M_u2 net90 net68 VSS VSS nch w=0.78u l=0.06u
MI27-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI59-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI55-M_u2 Q net90 VSS VSS nch w=0.39u l=0.06u
MI56-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI57-M_u2 QN net72 VSS VSS nch w=0.39u l=0.06u
MI58-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI44-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI49-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI54-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net72 net90 VDD VDD pch w=1.04u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.3u l=0.06u
MI22-M_u3 net90 net68 VDD VDD pch w=1.04u l=0.06u
MI27-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI59-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI55-M_u3 Q net90 VDD VDD pch w=0.52u l=0.06u
MI56-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI57-M_u3 QN net72 VDD VDD pch w=0.52u l=0.06u
MI58-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI50 net123 SA net108 VDD pch w=0.4u l=0.06u
MI21 net72 INCP net68 VDD pch w=0.15u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.48u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.34u l=0.06u
MI36 net123 net84 net110 VDD pch w=0.34u l=0.06u
MI38 net108 DB VDD VDD pch w=0.52u l=0.06u
MI39 net66 INCP net123 VDD pch w=0.24u l=0.06u
.ends
.subckt DFXQD1 DA DB SA CP Q VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.15u l=0.06u
MI30 net53 DB VSS VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.225u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net57 net84 net53 VSS nch w=0.39u l=0.06u
MI49 net68 INCPB net053 VSS nch w=0.15u l=0.06u
MI50 net053 net72 VSS VSS nch w=0.15u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.325u l=0.06u
MI22-M_u2 net72 net68 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.27u l=0.06u
MI22-M_u3 net72 net68 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.45u l=0.06u
MI52 net68 INCP net094 VDD pch w=0.15u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI51 net094 net72 VDD VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.34u l=0.06u
MI36 net108 net84 net110 VDD pch w=0.34u l=0.06u
MI37 net53 DB VDD VDD pch w=0.52u l=0.06u
MI38 net108 SA net53 VDD pch w=0.4u l=0.06u
MI39 net66 INCP net108 VDD pch w=0.27u l=0.06u
.ends
.subckt DFXQD2 DA DB SA CP Q VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.15u l=0.06u
MI51 net57 net84 net108 VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.225u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net108 DB VSS VSS nch w=0.39u l=0.06u
MI55 net059 net72 VSS VSS nch w=0.15u l=0.06u
MI49 net68 INCPB net059 VSS nch w=0.15u l=0.06u
MI44-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.325u l=0.06u
MI22-M_u2 net72 net68 VSS VSS nch w=0.78u l=0.06u
MI27-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI52-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI53-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI44-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.27u l=0.06u
MI22-M_u3 net72 net68 VDD VDD pch w=1.04u l=0.06u
MI27-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI52-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI53-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI50 net123 SA net108 VDD pch w=0.4u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.45u l=0.06u
MI57 net0105 net72 VDD VDD pch w=0.15u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI56 net68 INCP net0105 VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.34u l=0.06u
MI36 net123 net84 net110 VDD pch w=0.34u l=0.06u
MI38 net108 DB VDD VDD pch w=0.52u l=0.06u
MI39 net66 INCP net123 VDD pch w=0.27u l=0.06u
.ends
.subckt DFXQD4 DA DB SA CP Q VDD VSS
MI47 net66 INCP net75 VSS nch w=0.15u l=0.06u
MI26 net66 INCPB net57 VSS nch w=0.31u l=0.06u
MI51 net57 net84 net108 VSS nch w=0.39u l=0.06u
MI33 net57 SA net63 VSS nch w=0.21u l=0.06u
MI18 net76 INCP net68 VSS nch w=0.18u l=0.06u
MI48 net75 net76 VSS VSS nch w=0.15u l=0.06u
MI28 net63 DA VSS VSS nch w=0.21u l=0.06u
MI34 net108 DB VSS VSS nch w=0.39u l=0.06u
MI49 net68 INCPB net065 VSS nch w=0.15u l=0.06u
MI57 net065 net72 VSS VSS nch w=0.15u l=0.06u
MI44-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 net76 net66 VSS VSS nch w=0.315u l=0.06u
MI22_0-M_u2 net72 net68 VSS VSS nch w=0.39u l=0.06u
MI22_1-M_u2 net72 net68 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI52-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 Q net72 VSS VSS nch w=0.39u l=0.06u
MI35-M_u2 net84 SA VSS VSS nch w=0.195u l=0.06u
MI44-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 net76 net66 VDD VDD pch w=0.3u l=0.06u
MI22_0-M_u3 net72 net68 VDD VDD pch w=0.52u l=0.06u
MI22_1-M_u3 net72 net68 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI52-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 Q net72 VDD VDD pch w=0.52u l=0.06u
MI35-M_u3 net84 SA VDD VDD pch w=0.26u l=0.06u
MI50 net123 SA net108 VDD pch w=0.2u l=0.06u
MI20 net76 INCPB net68 VDD pch w=0.48u l=0.06u
MI59 net0110 net72 VDD VDD pch w=0.15u l=0.06u
MI43 net116 net76 VDD VDD pch w=0.15u l=0.06u
MI45 net66 INCPB net116 VDD pch w=0.15u l=0.06u
MI58 net68 INCP net0110 VDD pch w=0.15u l=0.06u
MI40 net110 DA VDD VDD pch w=0.32u l=0.06u
MI36 net123 net84 net110 VDD pch w=0.2u l=0.06u
MI38 net108 DB VDD VDD pch w=0.52u l=0.06u
MI39 net66 INCP net123 VDD pch w=0.24u l=0.06u
.ends
.subckt EDFCND1 D E CP CDN Q QN VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.29u l=0.06u
MI133 net116 d3 VSS VSS nch w=0.35u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI18 d3 INCPB net98 VSS nch w=0.15u l=0.06u
MI146 net114 E net64 VSS nch w=0.21u l=0.06u
MI15 d1 INCP net98 VSS nch w=0.235u l=0.06u
MI135 net64 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.35u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.39u l=0.06u
MI144-M_u3 d2 net98 XI144-net6 VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI148-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 d3 d2 VSS VSS nch w=0.195u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.4u l=0.06u
MI144-M_u1 d2 net98 VDD VDD pch w=0.4u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI148-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 d3 d2 VDD VDD pch w=0.26u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.29u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.15u l=0.06u
MI17 d3 INCP net98 VDD pch w=0.15u l=0.06u
MI16 d1 INCPB net98 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.335u l=0.06u
MI139 net64 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.38u l=0.06u
MI140 net129 d3 VDD VDD pch w=0.38u l=0.06u
MI145 net124 net119 net64 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFCND2 D E CP CDN Q QN VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.29u l=0.06u
MI133 net116 d3 VSS VSS nch w=0.35u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI18 d3 INCPB net98 VSS nch w=0.15u l=0.06u
MI15 d1 INCP net98 VSS nch w=0.235u l=0.06u
MI135 net219 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.35u l=0.06u
MI148 net114 E net219 VSS nch w=0.21u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI144-M_u3 d2 net98 XI144-net6 VSS nch w=0.2u l=0.06u
MI147-M_u4 XI147-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI147-M_u3 d2 net98 XI147-net6 VSS nch w=0.2u l=0.06u
MI145-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI146-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.18u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI150-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI151-M_u2 d3 d2 VSS VSS nch w=0.27u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.4u l=0.06u
MI144-M_u1 d2 net98 VDD VDD pch w=0.4u l=0.06u
MI147-M_u2 d2 CDN VDD VDD pch w=0.52u l=0.06u
MI147-M_u1 d2 net98 VDD VDD pch w=0.52u l=0.06u
MI145-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI146-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI150-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI151-M_u3 d3 d2 VDD VDD pch w=0.4u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.29u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.155u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.155u l=0.06u
MI17 d3 INCP net98 VDD pch w=0.15u l=0.06u
MI16 d1 INCPB net98 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.34u l=0.06u
MI139 net219 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.38u l=0.06u
MI140 net129 d3 VDD VDD pch w=0.38u l=0.06u
MI149 net124 net119 net219 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFCND4 D E CP CDN Q QN VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.29u l=0.06u
MI133 net116 d3 VSS VSS nch w=0.35u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI18 d3 INCPB net98 VSS nch w=0.15u l=0.06u
MI15 d1 INCP net98 VSS nch w=0.235u l=0.06u
MI135 net186 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.35u l=0.06u
MI153 net114 E net186 VSS nch w=0.21u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI144-M_u3 d2 net98 XI144-net6 VSS nch w=0.2u l=0.06u
MI151-M_u4 XI151-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI151-M_u3 d2 net98 XI151-net6 VSS nch w=0.2u l=0.06u
MI154-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI155-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI147-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.19u l=0.06u
MI148-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN d3 VSS VSS nch w=0.39u l=0.06u
MI156-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI150-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 d3 d2 VSS VSS nch w=0.465u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI149-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.4u l=0.06u
MI144-M_u1 d2 net98 VDD VDD pch w=0.4u l=0.06u
MI151-M_u2 d2 CDN VDD VDD pch w=0.52u l=0.06u
MI151-M_u1 d2 net98 VDD VDD pch w=0.52u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.155u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.155u l=0.06u
MI17 d3 INCP net98 VDD pch w=0.15u l=0.06u
MI16 d1 INCPB net98 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.34u l=0.06u
MI139 net186 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.38u l=0.06u
MI140 net129 d3 VDD VDD pch w=0.38u l=0.06u
MI152 net124 net119 net186 VDD pch w=0.34u l=0.06u
MI154-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI155-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI147-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI148-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN d3 VDD VDD pch w=0.52u l=0.06u
MI156-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI150-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 d3 d2 VDD VDD pch w=0.66u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.26u l=0.06u
MI149-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt EDFCNQD1 D E CP CDN Q VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.29u l=0.06u
MI133 net116 net64 VSS VSS nch w=0.35u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI18 net64 INCPB net98 VSS nch w=0.15u l=0.06u
MI15 d1 INCP net98 VSS nch w=0.17u l=0.06u
MI135 net81 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.35u l=0.06u
MI145 net114 E net81 VSS nch w=0.21u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI144-M_u3 d2 net98 XI144-net6 VSS nch w=0.23u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net64 d2 VSS VSS nch w=0.15u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.4u l=0.06u
MI144-M_u1 d2 net98 VDD VDD pch w=0.4u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net64 d2 VDD VDD pch w=0.2u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.34u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.15u l=0.06u
MI17 net64 INCP net98 VDD pch w=0.15u l=0.06u
MI16 d1 INCPB net98 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.34u l=0.06u
MI139 net81 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.38u l=0.06u
MI140 net129 net64 VDD VDD pch w=0.38u l=0.06u
MI146 net124 net119 net81 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFCNQD2 D E CP CDN Q VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.29u l=0.06u
MI133 net116 net187 VSS VSS nch w=0.35u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI15 d1 INCP net85 VSS nch w=0.17u l=0.06u
MI135 net72 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.35u l=0.06u
MI18 net187 INCPB net85 VSS nch w=0.15u l=0.06u
MI147 net114 E net72 VSS nch w=0.21u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.19u l=0.06u
MI144-M_u3 d2 net85 XI144-net6 VSS nch w=0.19u l=0.06u
MI149-M_u4 XI149-net6 CDN VSS VSS nch w=0.19u l=0.06u
MI149-M_u3 d2 net85 XI149-net6 VSS nch w=0.19u l=0.06u
MI150-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI151-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net187 d2 VSS VSS nch w=0.195u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.46u l=0.06u
MI144-M_u1 d2 net85 VDD VDD pch w=0.46u l=0.06u
MI149-M_u2 d2 CDN VDD VDD pch w=0.46u l=0.06u
MI149-M_u1 d2 net85 VDD VDD pch w=0.46u l=0.06u
MI150-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI151-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net187 d2 VDD VDD pch w=0.26u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.34u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.15u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.15u l=0.06u
MI16 d1 INCPB net85 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.34u l=0.06u
MI139 net72 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.38u l=0.06u
MI140 net129 net187 VDD VDD pch w=0.38u l=0.06u
MI17 net187 INCP net85 VDD pch w=0.15u l=0.06u
MI148 net124 net119 net72 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFCNQD4 D E CP CDN Q VDD VSS
MI132 d0 INCPB net114 VSS nch w=0.295u l=0.06u
MI133 net116 net187 VSS VSS nch w=0.29u l=0.06u
MI49 net89 CDN VSS VSS nch w=0.15u l=0.06u
MI48 net92 d1 net89 VSS nch w=0.15u l=0.06u
MI47 d0 INCP net92 VSS nch w=0.15u l=0.06u
MI15 d1 INCP net85 VSS nch w=0.235u l=0.06u
MI135 net72 D VSS VSS nch w=0.21u l=0.06u
MI136 net114 net119 net116 VSS nch w=0.29u l=0.06u
MI18 net187 INCPB net85 VSS nch w=0.15u l=0.06u
MI147 net114 E net72 VSS nch w=0.21u l=0.06u
MI144-M_u4 XI144-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI144-M_u3 d2 net85 XI144-net6 VSS nch w=0.2u l=0.06u
MI149-M_u4 XI149-net6 CDN VSS VSS nch w=0.2u l=0.06u
MI149-M_u3 d2 net85 XI149-net6 VSS nch w=0.2u l=0.06u
MI145-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.18u l=0.06u
MI27-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI150-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI154-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI151-M_u2 Q d2 VSS VSS nch w=0.39u l=0.06u
MI152-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net187 d2 VSS VSS nch w=0.195u l=0.06u
MI137-M_u2 net119 E VSS VSS nch w=0.195u l=0.06u
MI144-M_u2 d2 CDN VDD VDD pch w=0.46u l=0.06u
MI144-M_u1 d2 net85 VDD VDD pch w=0.46u l=0.06u
MI149-M_u2 d2 CDN VDD VDD pch w=0.46u l=0.06u
MI149-M_u1 d2 net85 VDD VDD pch w=0.46u l=0.06u
MI145-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI27-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI150-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI154-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI151-M_u3 Q d2 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net187 d2 VDD VDD pch w=0.26u l=0.06u
MI137-M_u3 net119 E VDD VDD pch w=0.26u l=0.06u
MI44 net79 CDN VDD VDD pch w=0.15u l=0.06u
MI43 net79 d1 VDD VDD pch w=0.155u l=0.06u
MI45 d0 INCPB net79 VDD pch w=0.155u l=0.06u
MI16 d1 INCPB net85 VDD pch w=0.39u l=0.06u
MI138 d0 INCP net124 VDD pch w=0.34u l=0.06u
MI139 net72 D VDD VDD pch w=0.34u l=0.06u
MI141 net124 E net129 VDD pch w=0.36u l=0.06u
MI140 net129 net187 VDD VDD pch w=0.36u l=0.06u
MI17 net187 INCP net85 VDD pch w=0.15u l=0.06u
MI148 net124 net119 net72 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFD1 D E CP Q QN VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net59 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI55 net99 INCPB net76 VSS nch w=0.15u l=0.06u
MI65 net84 INCP net76 VSS nch w=0.23u l=0.06u
MI78 net98 net99 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI89 net92 E net59 VSS nch w=0.21u l=0.06u
MI91-M_u2 net99 net58 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net99 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net58 VSS VSS nch w=0.39u l=0.06u
MI73-M_u2 net58 net76 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.15u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI91-M_u3 net99 net58 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net99 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net58 VDD VDD pch w=0.52u l=0.06u
MI73-M_u3 net58 net76 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.29u l=0.06u
MI90 net114 net103 net59 VDD pch w=0.34u l=0.06u
MI67 net84 INCPB net76 VDD pch w=0.54u l=0.06u
MI68 net99 INCP net76 VDD pch w=0.15u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI85 net110 net99 VDD VDD pch w=0.38u l=0.06u
MI84 net59 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFD2 D E CP Q QN VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net59 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI55 net101 INCPB net76 VSS nch w=0.15u l=0.06u
MI65 net84 INCP net76 VSS nch w=0.23u l=0.06u
MI78 net98 net101 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI89 net92 E net59 VSS nch w=0.21u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net101 VSS VSS nch w=0.78u l=0.06u
MI27-M_u2 Q net60 VSS VSS nch w=0.78u l=0.06u
MI73-M_u2 net60 net76 VSS VSS nch w=0.78u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.15u l=0.06u
MI75-M_u2 net101 net60 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net101 VDD VDD pch w=1.04u l=0.06u
MI27-M_u3 Q net60 VDD VDD pch w=1.04u l=0.06u
MI73-M_u3 net60 net76 VDD VDD pch w=1.04u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI75-M_u3 net101 net60 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.29u l=0.06u
MI90 net114 net103 net59 VDD pch w=0.34u l=0.06u
MI67 net84 INCPB net76 VDD pch w=0.34u l=0.06u
MI68 net101 INCP net76 VDD pch w=0.15u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI85 net110 net101 VDD VDD pch w=0.38u l=0.06u
MI84 net59 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFD4 D E CP Q QN VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net59 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI55 net101 INCPB net76 VSS nch w=0.15u l=0.06u
MI65 net84 INCP net76 VSS nch w=0.235u l=0.06u
MI78 net98 net101 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI90 net92 E net59 VSS nch w=0.21u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI89_0-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI89_1-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI89_2-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI89_3-M_u2 QN net101 VSS VSS nch w=0.39u l=0.06u
MI27_0-M_u2 Q net50 VSS VSS nch w=0.39u l=0.06u
MI27_1-M_u2 Q net50 VSS VSS nch w=0.39u l=0.06u
MI27_2-M_u2 Q net50 VSS VSS nch w=0.39u l=0.06u
MI27_3-M_u2 Q net50 VSS VSS nch w=0.39u l=0.06u
MI73_0-M_u2 net50 net76 VSS VSS nch w=0.39u l=0.06u
MI73_1-M_u2 net50 net76 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.15u l=0.06u
MI75-M_u2 net101 net50 VSS VSS nch w=0.78u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI89_0-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI89_1-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI89_2-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI89_3-M_u3 QN net101 VDD VDD pch w=0.52u l=0.06u
MI27_0-M_u3 Q net50 VDD VDD pch w=0.52u l=0.06u
MI27_1-M_u3 Q net50 VDD VDD pch w=0.52u l=0.06u
MI27_2-M_u3 Q net50 VDD VDD pch w=0.52u l=0.06u
MI27_3-M_u3 Q net50 VDD VDD pch w=0.52u l=0.06u
MI73_0-M_u3 net50 net76 VDD VDD pch w=0.52u l=0.06u
MI73_1-M_u3 net50 net76 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI75-M_u3 net101 net50 VDD VDD pch w=1.04u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.26u l=0.06u
MI91 net114 net103 net59 VDD pch w=0.34u l=0.06u
MI67 net84 INCPB net76 VDD pch w=0.52u l=0.06u
MI68 net101 INCP net76 VDD pch w=0.15u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI85 net110 net101 VDD VDD pch w=0.38u l=0.06u
MI84 net59 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCND1 D E CP CN Q QN VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI64 net103 INCPB net86 VSS nch w=0.15u l=0.06u
MI65 net82 INCP net86 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net103 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI88-M_u2 net103 net56 VSS VSS nch w=0.195u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net56 net86 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.21u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI88-M_u3 net103 net56 VDD VDD pch w=0.26u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net56 net86 VDD VDD pch w=0.5u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI52 net82 INCPB net86 VDD pch w=0.52u l=0.06u
MI66 net103 INCP net86 VDD pch w=0.15u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net103 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCND2 D E CP CN Q QN VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI64 net103 INCPB net86 VSS nch w=0.15u l=0.06u
MI65 net82 INCP net86 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net103 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI90-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI91-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net56 net86 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.21u l=0.06u
MI14-M_u2 net103 net56 VSS VSS nch w=0.39u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI90-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI91-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI29-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net56 net86 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI14-M_u3 net103 net56 VDD VDD pch w=0.52u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI52 net82 INCPB net86 VDD pch w=0.325u l=0.06u
MI66 net103 INCP net86 VDD pch w=0.16u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net103 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCND4 D E CP CN Q QN VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI64 net103 INCPB net92 VSS nch w=0.15u l=0.06u
MI65 net82 INCP net92 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net103 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI94-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI95-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI89-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI91-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI92-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI93-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI96-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI97-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 QN net103 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI68_0-M_u2 net56 net92 VSS VSS nch w=0.39u l=0.06u
MI68_1-M_u2 net56 net92 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.21u l=0.06u
MI14-M_u2 net103 net56 VSS VSS nch w=0.78u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI94-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI95-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI89-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI91-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI92-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI93-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI96-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI97-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 QN net103 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI68_0-M_u3 net56 net92 VDD VDD pch w=0.52u l=0.06u
MI68_1-M_u3 net56 net92 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI14-M_u3 net103 net56 VDD VDD pch w=1.04u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI52 net82 INCPB net92 VDD pch w=0.52u l=0.06u
MI66 net103 INCP net92 VDD pch w=0.15u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net103 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCNQD1 D E CP CN Q VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI64 net103 INCPB net86 VSS nch w=0.15u l=0.06u
MI65 net82 INCP net86 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net103 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net56 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net56 net86 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.21u l=0.06u
MI14-M_u2 net103 net56 VSS VSS nch w=0.15u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net56 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net56 net86 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI14-M_u3 net103 net56 VDD VDD pch w=0.2u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI52 net82 INCPB net86 VDD pch w=0.52u l=0.06u
MI66 net103 INCP net86 VDD pch w=0.15u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net103 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCNQD2 D E CP CN Q VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI65 net82 INCP net69 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI18 net59 INCPB net69 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net59 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI88-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI68-M_u2 net103 net69 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.15u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net59 net103 VSS VSS nch w=0.15u l=0.06u
MI88-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI68-M_u3 net103 net69 VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI14-M_u3 net59 net103 VDD VDD pch w=0.2u l=0.06u
MI52 net82 INCPB net69 VDD pch w=0.52u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI17 net59 INCP net69 VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net59 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFKCNQD4 D E CP CN Q VDD VSS
MI47 net90 INCP net77 VSS nch w=0.15u l=0.06u
MI63 net77 net82 VSS VSS nch w=0.15u l=0.06u
MI65 net82 INCP net86 VSS nch w=0.235u l=0.06u
MI76 net98 CN VSS VSS nch w=0.39u l=0.06u
MI74 net96 D net99 VSS nch w=0.15u l=0.06u
MI18 net97 INCPB net86 VSS nch w=0.15u l=0.06u
MI73 net99 E net98 VSS nch w=0.15u l=0.06u
MI72 net104 net97 net98 VSS nch w=0.2u l=0.06u
MI75 net96 net107 net104 VSS nch w=0.2u l=0.06u
MI87 net90 INCPB net96 VSS nch w=0.29u l=0.06u
MI88-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI90-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI91-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net103 VSS VSS nch w=0.39u l=0.06u
MI68_0-M_u2 net103 net86 VSS VSS nch w=0.39u l=0.06u
MI68_1-M_u2 net103 net86 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net82 net90 VSS VSS nch w=0.21u l=0.06u
MI77-M_u2 net107 E VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net97 net103 VSS VSS nch w=0.15u l=0.06u
MI88-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI90-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI91-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net103 VDD VDD pch w=0.52u l=0.06u
MI68_0-M_u3 net103 net86 VDD VDD pch w=0.52u l=0.06u
MI68_1-M_u3 net103 net86 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net82 net90 VDD VDD pch w=0.34u l=0.06u
MI77-M_u3 net107 E VDD VDD pch w=0.43u l=0.06u
MI14-M_u3 net97 net103 VDD VDD pch w=0.2u l=0.06u
MI17 net97 INCP net86 VDD pch w=0.15u l=0.06u
MI52 net82 INCPB net86 VDD pch w=0.315u l=0.06u
MI45 net90 INCPB net70 VDD pch w=0.15u l=0.06u
MI67 net70 net82 VDD VDD pch w=0.15u l=0.06u
MI78 net118 D net120 VDD pch w=0.23u l=0.06u
MI82 net118 CN VDD VDD pch w=0.47u l=0.06u
MI81 net120 net107 VDD VDD pch w=0.23u l=0.06u
MI80 net118 E net111 VDD pch w=0.31u l=0.06u
MI79 net111 net97 VDD VDD pch w=0.47u l=0.06u
MI86 net118 INCP net90 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFQD1 D E CP Q VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net123 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI65 net84 INCP net71 VSS nch w=0.235u l=0.06u
MI78 net98 net58 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI18 net58 INCPB net71 VSS nch w=0.15u l=0.06u
MI90 net92 E net123 VSS nch w=0.21u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net170 VSS VSS nch w=0.39u l=0.06u
MI73-M_u2 net170 net71 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.21u l=0.06u
MI14-M_u2 net58 net170 VSS VSS nch w=0.15u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net170 VDD VDD pch w=0.52u l=0.06u
MI73-M_u3 net170 net71 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI14-M_u3 net58 net170 VDD VDD pch w=0.2u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.26u l=0.06u
MI67 net84 INCPB net71 VDD pch w=0.52u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI85 net110 net58 VDD VDD pch w=0.38u l=0.06u
MI84 net123 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
MI17 net58 INCP net71 VDD pch w=0.15u l=0.06u
MI89 net114 net103 net123 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFQD2 D E CP Q VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net61 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI65 net84 INCP net76 VSS nch w=0.235u l=0.06u
MI78 net98 net60 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI18 net60 INCPB net76 VSS nch w=0.15u l=0.06u
MI90 net92 E net61 VSS nch w=0.21u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 Q net96 VSS VSS nch w=0.78u l=0.06u
MI73-M_u2 net96 net76 VSS VSS nch w=0.78u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.21u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net60 net96 VSS VSS nch w=0.15u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 Q net96 VDD VDD pch w=1u l=0.06u
MI73-M_u3 net96 net76 VDD VDD pch w=1u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net60 net96 VDD VDD pch w=0.2u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI17 net60 INCP net76 VDD pch w=0.16u l=0.06u
MI85 net110 net60 VDD VDD pch w=0.38u l=0.06u
MI84 net61 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
MI67 net84 INCPB net76 VDD pch w=0.52u l=0.06u
MI89 net114 net103 net61 VDD pch w=0.34u l=0.06u
.ends
.subckt EDFQD4 D E CP Q VDD VSS
MI81 net92 net103 net98 VSS nch w=0.35u l=0.06u
MI80 net61 D VSS VSS nch w=0.21u l=0.06u
MI63 net117 INCP net85 VSS nch w=0.15u l=0.06u
MI64 net85 net84 VSS VSS nch w=0.15u l=0.06u
MI65 net84 INCP net76 VSS nch w=0.235u l=0.06u
MI78 net98 net60 VSS VSS nch w=0.35u l=0.06u
MI77 net117 INCPB net92 VSS nch w=0.29u l=0.06u
MI18 net60 INCPB net76 VSS nch w=0.15u l=0.06u
MI90 net92 E net61 VSS nch w=0.21u l=0.06u
MI94-M_u2 Q net176 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 net60 net176 VSS VSS nch w=0.15u l=0.06u
MI91-M_u2 Q net176 VSS VSS nch w=0.39u l=0.06u
MI32-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net176 VSS VSS nch w=0.39u l=0.06u
MI73_0-M_u2 net176 net76 VSS VSS nch w=0.39u l=0.06u
MI73_1-M_u2 net176 net76 VSS VSS nch w=0.39u l=0.06u
MI74-M_u2 net84 net117 VSS VSS nch w=0.21u l=0.06u
MI92-M_u2 Q net176 VSS VSS nch w=0.39u l=0.06u
MI82-M_u2 net103 E VSS VSS nch w=0.195u l=0.06u
MI94-M_u3 Q net176 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 net60 net176 VDD VDD pch w=0.2u l=0.06u
MI91-M_u3 Q net176 VDD VDD pch w=0.52u l=0.06u
MI32-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net176 VDD VDD pch w=0.52u l=0.06u
MI73_0-M_u3 net176 net76 VDD VDD pch w=0.52u l=0.06u
MI73_1-M_u3 net176 net76 VDD VDD pch w=0.52u l=0.06u
MI74-M_u3 net84 net117 VDD VDD pch w=0.34u l=0.06u
MI92-M_u3 Q net176 VDD VDD pch w=0.52u l=0.06u
MI82-M_u3 net103 E VDD VDD pch w=0.26u l=0.06u
MI69 net117 INCPB net69 VDD pch w=0.15u l=0.06u
MI70 net69 net84 VDD VDD pch w=0.15u l=0.06u
MI17 net60 INCP net76 VDD pch w=0.15u l=0.06u
MI86 net114 E net110 VDD pch w=0.38u l=0.06u
MI85 net110 net60 VDD VDD pch w=0.38u l=0.06u
MI84 net61 D VDD VDD pch w=0.34u l=0.06u
MI83 net117 INCP net114 VDD pch w=0.34u l=0.06u
MI67 net84 INCPB net76 VDD pch w=0.52u l=0.06u
MI89 net114 net103 net61 VDD pch w=0.34u l=0.06u
.ends
.subckt FA1D0 A B CI S CO VDD VSS
MI21-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MI17-M_u2 net77 net67 VSS VSS nch w=0.35u l=0.06u
MI19-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 S net54 VSS VSS nch w=0.195u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU28-M_u2 CO net24 VSS VSS nch w=0.195u l=0.06u
MI18-M_u2 net67 CI VSS VSS nch w=0.35u l=0.06u
MI20-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net77 net32 net54 VSS nch w=0.35u l=0.06u
MU17-M_u3 net67 net44 net54 VSS nch w=0.17u l=0.06u
MI14-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.39u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI21-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI17-M_u3 net77 net67 VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 S net54 VDD VDD pch w=0.26u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU28-M_u3 CO net24 VDD VDD pch w=0.26u l=0.06u
MI18-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MI20-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MI15-M_u2 net77 net44 net54 VDD pch w=0.44u l=0.06u
MU17-M_u2 net67 net32 net54 VDD pch w=0.26u l=0.06u
MI14-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.4u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.46u l=0.06u
.ends
.subckt FA1D1 A B CI S CO VDD VSS
MI17-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net77 net67 VSS VSS nch w=0.265u l=0.06u
MI12_0-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU28-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU26_0-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MU26_1-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net77 net32 net54 VSS nch w=0.32u l=0.06u
MI18-M_u3 net67 net44 net54 VSS nch w=0.17u l=0.06u
MI21-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.32u l=0.06u
MI19-M_u3 net67 net32 net24 VSS nch w=0.32u l=0.06u
MI20-M_u3 net36 net44 net24 VSS nch w=0.2u l=0.06u
MI17-M_u3 net44 net32 VDD VDD pch w=0.49u l=0.06u
MI16-M_u3 net77 net67 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.49u l=0.06u
MU28-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU26_0-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MU26_1-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MI15-M_u2 net77 net44 net54 VDD pch w=0.45u l=0.06u
MI18-M_u2 net67 net32 net54 VDD pch w=0.26u l=0.06u
MI21-M_u2 net34 net36 net32 VDD pch w=0.305u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.41u l=0.06u
MI19-M_u2 net67 net44 net24 VDD pch w=0.45u l=0.06u
MI20-M_u2 net36 net32 net24 VDD pch w=0.38u l=0.06u
.ends
.subckt FA1D2 A B CI S CO VDD VSS
MI16-M_u2 net77 net67 VSS VSS nch w=0.245u l=0.06u
MI12_0-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU26_0-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MU26_1-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net77 net32 net54 VSS nch w=0.245u l=0.06u
MU17-M_u3 net67 net44 net54 VSS nch w=0.15u l=0.06u
MI14-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.39u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.17u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.39u l=0.06u
MI16-M_u3 net77 net67 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.49u l=0.06u
MI17_0-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MI17_1-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU26_0-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MU26_1-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.49u l=0.06u
MI15-M_u2 net77 net44 net54 VDD pch w=0.33u l=0.06u
MU17-M_u2 net67 net32 net54 VDD pch w=0.15u l=0.06u
MI14-M_u2 net34 net36 net32 VDD pch w=0.305u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.4u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.18u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.35u l=0.06u
.ends
.subckt FA1D4 A B CI S CO VDD VSS
MI16_0-M_u2 net50 net67 VSS VSS nch w=0.39u l=0.06u
MI16_1-M_u2 net50 net67 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 net64 net34 VSS VSS nch w=0.355u l=0.06u
MI12_1-M_u2 net64 net34 VSS VSS nch w=0.355u l=0.06u
MU18_0-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU18_2-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU18_3-M_u2 S net54 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3_0-M_u2 net36 B VSS VSS nch w=0.355u l=0.06u
MU3_1-M_u2 net36 B VSS VSS nch w=0.355u l=0.06u
MU28_0-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU28_1-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU28_2-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU28_3-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u2 net67 CI VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net50 net32 net54 VSS nch w=0.35u l=0.06u
MU17-M_u3 net67 net44 net54 VSS nch w=0.17u l=0.06u
MI14-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.33u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI16_0-M_u3 net50 net67 VDD VDD pch w=0.52u l=0.06u
MI16_1-M_u3 net50 net67 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU18_2-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU18_3-M_u3 S net54 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3_0-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU3_1-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU28_0-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU28_1-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU28_2-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU28_3-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MI17_0-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MI17_1-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI15-M_u2 net50 net44 net54 VDD pch w=0.44u l=0.06u
MU17-M_u2 net67 net32 net54 VDD pch w=0.26u l=0.06u
MI14-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.4u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.46u l=0.06u
.ends
.subckt FCICIND1 A B CIN CO VDD VSS
MI22-M_u2 net38 CIN VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 CO net34 VSS VSS nch w=0.39u l=0.06u
MU10 net75 net38 VSS VSS nch w=0.26u l=0.06u
MU7 net63 B VSS VSS nch w=0.2u l=0.06u
MU9 net75 A net34 VSS nch w=0.355u l=0.06u
MI1 net75 B net34 VSS nch w=0.26u l=0.06u
MU6 net34 A net63 VSS nch w=0.355u l=0.06u
MI22-M_u3 net38 CIN VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 CO net34 VDD VDD pch w=0.52u l=0.06u
MU3 net34 A net55 VDD pch w=0.47u l=0.06u
MU5 net50 A net34 VDD pch w=0.47u l=0.06u
MU4 net50 B net34 VDD pch w=0.47u l=0.06u
MU1 net50 net38 VDD VDD pch w=0.47u l=0.06u
MU2 net55 B VDD VDD pch w=0.47u l=0.06u
.ends
.subckt FCICIND2 A B CIN CO VDD VSS
MI22-M_u2 net38 CIN VSS VSS nch w=0.39u l=0.06u
MI15_0-M_u2 CO net34 VSS VSS nch w=0.39u l=0.06u
MI15_1-M_u2 CO net34 VSS VSS nch w=0.39u l=0.06u
MU10 net75 net38 VSS VSS nch w=0.26u l=0.06u
MU7 net63 B VSS VSS nch w=0.2u l=0.06u
MU9 net75 A net34 VSS nch w=0.355u l=0.06u
MI1 net75 B net34 VSS nch w=0.26u l=0.06u
MU6 net34 A net63 VSS nch w=0.355u l=0.06u
MI22-M_u3 net38 CIN VDD VDD pch w=0.52u l=0.06u
MI15_0-M_u3 CO net34 VDD VDD pch w=0.52u l=0.06u
MI15_1-M_u3 CO net34 VDD VDD pch w=0.52u l=0.06u
MU3 net34 A net55 VDD pch w=0.47u l=0.06u
MU5 net50 A net34 VDD pch w=0.47u l=0.06u
MU4 net50 B net34 VDD pch w=0.47u l=0.06u
MU1 net50 net38 VDD VDD pch w=0.47u l=0.06u
MU2 net55 B VDD VDD pch w=0.47u l=0.06u
.ends
.subckt FCICOND1 A B CI CON VDD VSS
MU9 net47 A CON VSS nch w=0.39u l=0.06u
MU10 net47 CI VSS VSS nch w=0.21u l=0.06u
MI1 net47 B CON VSS nch w=0.21u l=0.06u
MU6 CON A net35 VSS nch w=0.365u l=0.06u
MU7 net35 B VSS VSS nch w=0.21u l=0.06u
MU3 CON A net27 VDD pch w=0.52u l=0.06u
MU2 net27 B VDD VDD pch w=0.52u l=0.06u
MU5 net22 A CON VDD pch w=0.52u l=0.06u
MU4 net22 B CON VDD pch w=0.52u l=0.06u
MU1 net22 CI VDD VDD pch w=0.52u l=0.06u
.ends
.subckt FCICOND2 A B CI CON VDD VSS
MU9 net47 A net64 VSS nch w=0.39u l=0.06u
MU10 net47 CI VSS VSS nch w=0.21u l=0.06u
MI1 net47 B net64 VSS nch w=0.21u l=0.06u
MU6 net64 A net35 VSS nch w=0.365u l=0.06u
MU7 net35 B VSS VSS nch w=0.21u l=0.06u
MI61_0-M_u2 CON net39 VSS VSS nch w=0.39u l=0.06u
MI61_1-M_u2 CON net39 VSS VSS nch w=0.39u l=0.06u
MI45-M_u2 net39 net64 VSS VSS nch w=0.39u l=0.06u
MI61_0-M_u3 CON net39 VDD VDD pch w=0.52u l=0.06u
MI61_1-M_u3 CON net39 VDD VDD pch w=0.52u l=0.06u
MI45-M_u3 net39 net64 VDD VDD pch w=0.52u l=0.06u
MU3 net64 A net27 VDD pch w=0.52u l=0.06u
MU2 net27 B VDD VDD pch w=0.52u l=0.06u
MU5 net22 A net64 VDD pch w=0.52u l=0.06u
MU4 net22 B net64 VDD pch w=0.52u l=0.06u
MU1 net22 CI VDD VDD pch w=0.52u l=0.06u
.ends
.subckt FCSICIND1 A B CIN0 CIN1 CS S CO0 CO1 VDD VSS
MI43_0-M_u2 net101 net34 VSS VSS nch w=0.39u l=0.06u
MI43_1-M_u2 net101 net34 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 net52 net32 VSS VSS nch w=0.23u l=0.06u
MI41-M_u2 net82 CIN1 VSS VSS nch w=0.35u l=0.06u
MI30-M_u2 net146 CS VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 S net150 VSS VSS nch w=0.39u l=0.06u
MI19-M_u2 CO1 net54 VSS VSS nch w=0.37u l=0.06u
MI40-M_u2 net84 net82 VSS VSS nch w=0.23u l=0.06u
MI39-M_u2 net67 net78 VSS VSS nch w=0.23u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net55 B VSS VSS nch w=0.39u l=0.06u
MU28-M_u2 CO0 net24 VSS VSS nch w=0.37u l=0.06u
MU26-M_u2 net78 CIN0 VSS VSS nch w=0.35u l=0.06u
MU4-M_u2 net155 net32 VSS VSS nch w=0.21u l=0.06u
MI27-M_u3 net81 CS net150 VSS nch w=0.21u l=0.06u
MI36-M_u3 net55 net52 net54 VSS nch w=0.19u l=0.06u
MI26-M_u3 net206 net146 net150 VSS nch w=0.2u l=0.06u
MI35-M_u3 net84 net32 net54 VSS nch w=0.35u l=0.06u
MI13-M_u3 net78 net32 net206 VSS nch w=0.17u l=0.06u
MI34-M_u3 net55 net155 net24 VSS nch w=0.19u l=0.06u
MI42-M_u3 net101 net55 net32 VSS nch w=0.39u l=0.06u
MI38-M_u3 net84 net52 net81 VSS nch w=0.17u l=0.06u
MI37-M_u3 net82 net32 net81 VSS nch w=0.35u l=0.06u
MI32-M_u3 net67 net155 net206 VSS nch w=0.17u l=0.06u
MI44-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI33-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI43_0-M_u3 net101 net34 VDD VDD pch w=0.52u l=0.06u
MI43_1-M_u3 net101 net34 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 net52 net32 VDD VDD pch w=0.44u l=0.06u
MI41-M_u3 net82 CIN1 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 net146 CS VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 S net150 VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 CO1 net54 VDD VDD pch w=0.44u l=0.06u
MI40-M_u3 net84 net82 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 net67 net78 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net55 B VDD VDD pch w=0.52u l=0.06u
MU28-M_u3 CO0 net24 VDD VDD pch w=0.44u l=0.06u
MU26-M_u3 net78 CIN0 VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net155 net32 VDD VDD pch w=0.44u l=0.06u
MI27-M_u2 net81 net146 net150 VDD pch w=0.34u l=0.06u
MI36-M_u2 net55 net32 net54 VDD pch w=0.4u l=0.06u
MI26-M_u2 net206 CS net150 VDD pch w=0.4u l=0.06u
MI35-M_u2 net84 net52 net54 VDD pch w=0.4u l=0.06u
MI13-M_u2 net78 net155 net206 VDD pch w=0.44u l=0.06u
MI34-M_u2 net55 net32 net24 VDD pch w=0.4u l=0.06u
MI42-M_u2 net101 B net32 VDD pch w=0.4u l=0.06u
MI38-M_u2 net84 net32 net81 VDD pch w=0.28u l=0.06u
MI37-M_u2 net82 net52 net81 VDD pch w=0.44u l=0.06u
MI32-M_u2 net67 net32 net206 VDD pch w=0.28u l=0.06u
MI44-M_u2 net34 net55 net32 VDD pch w=0.34u l=0.06u
MI33-M_u2 net67 net155 net24 VDD pch w=0.4u l=0.06u
.ends
.subckt FCSICIND2 A B CIN0 CIN1 CS S CO0 CO1 VDD VSS
MI43_0-M_u2 net101 net34 VSS VSS nch w=0.39u l=0.06u
MI43_1-M_u2 net101 net34 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 net52 net32 VSS VSS nch w=0.23u l=0.06u
MI41-M_u2 net82 CIN1 VSS VSS nch w=0.35u l=0.06u
MI30-M_u2 net146 CS VSS VSS nch w=0.39u l=0.06u
MI31_0-M_u2 S net150 VSS VSS nch w=0.195u l=0.06u
MI31_1-M_u2 S net150 VSS VSS nch w=0.195u l=0.06u
MI19_0-M_u2 CO1 net54 VSS VSS nch w=0.37u l=0.06u
MI19_1-M_u2 CO1 net54 VSS VSS nch w=0.37u l=0.06u
MI40-M_u2 net84 net82 VSS VSS nch w=0.23u l=0.06u
MI39-M_u2 net67 net78 VSS VSS nch w=0.23u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net55 B VSS VSS nch w=0.39u l=0.06u
MU28_0-M_u2 CO0 net24 VSS VSS nch w=0.37u l=0.06u
MU28_1-M_u2 CO0 net24 VSS VSS nch w=0.37u l=0.06u
MU26-M_u2 net78 CIN0 VSS VSS nch w=0.35u l=0.06u
MU4-M_u2 net155 net32 VSS VSS nch w=0.21u l=0.06u
MI27-M_u3 net81 CS net150 VSS nch w=0.21u l=0.06u
MI36-M_u3 net55 net52 net54 VSS nch w=0.19u l=0.06u
MI26-M_u3 net206 net146 net150 VSS nch w=0.2u l=0.06u
MI35-M_u3 net84 net32 net54 VSS nch w=0.35u l=0.06u
MI13-M_u3 net78 net32 net206 VSS nch w=0.17u l=0.06u
MI34-M_u3 net55 net155 net24 VSS nch w=0.19u l=0.06u
MI42-M_u3 net101 net55 net32 VSS nch w=0.39u l=0.06u
MI38-M_u3 net84 net52 net81 VSS nch w=0.17u l=0.06u
MI37-M_u3 net82 net32 net81 VSS nch w=0.35u l=0.06u
MI32-M_u3 net67 net155 net206 VSS nch w=0.17u l=0.06u
MI44-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI33-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI43_0-M_u3 net101 net34 VDD VDD pch w=0.52u l=0.06u
MI43_1-M_u3 net101 net34 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 net52 net32 VDD VDD pch w=0.44u l=0.06u
MI41-M_u3 net82 CIN1 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 net146 CS VDD VDD pch w=0.52u l=0.06u
MI31_0-M_u3 S net150 VDD VDD pch w=0.26u l=0.06u
MI31_1-M_u3 S net150 VDD VDD pch w=0.26u l=0.06u
MI19_0-M_u3 CO1 net54 VDD VDD pch w=0.44u l=0.06u
MI19_1-M_u3 CO1 net54 VDD VDD pch w=0.44u l=0.06u
MI40-M_u3 net84 net82 VDD VDD pch w=0.52u l=0.06u
MI39-M_u3 net67 net78 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net55 B VDD VDD pch w=0.52u l=0.06u
MU28_0-M_u3 CO0 net24 VDD VDD pch w=0.44u l=0.06u
MU28_1-M_u3 CO0 net24 VDD VDD pch w=0.44u l=0.06u
MU26-M_u3 net78 CIN0 VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net155 net32 VDD VDD pch w=0.44u l=0.06u
MI27-M_u2 net81 net146 net150 VDD pch w=0.34u l=0.06u
MI36-M_u2 net55 net32 net54 VDD pch w=0.4u l=0.06u
MI26-M_u2 net206 CS net150 VDD pch w=0.4u l=0.06u
MI35-M_u2 net84 net52 net54 VDD pch w=0.4u l=0.06u
MI13-M_u2 net78 net155 net206 VDD pch w=0.44u l=0.06u
MI34-M_u2 net55 net32 net24 VDD pch w=0.4u l=0.06u
MI42-M_u2 net101 B net32 VDD pch w=0.4u l=0.06u
MI38-M_u2 net84 net32 net81 VDD pch w=0.28u l=0.06u
MI37-M_u2 net82 net52 net81 VDD pch w=0.44u l=0.06u
MI32-M_u2 net67 net32 net206 VDD pch w=0.28u l=0.06u
MI44-M_u2 net34 net55 net32 VDD pch w=0.34u l=0.06u
MI33-M_u2 net67 net155 net24 VDD pch w=0.4u l=0.06u
.ends
.subckt FCSICOND1 A B CI0 CI1 CS S CON0 CON1 VDD VSS
MI23 net80 net133 VSS VSS nch w=0.2u l=0.06u
MI22 net83 net32 net80 VSS nch w=0.2u l=0.06u
MI32-M_u2 net44 net32 VSS VSS nch w=0.37u l=0.06u
MI49-M_u2 net165 net67 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 CON1 net127 VSS VSS nch w=0.37u l=0.06u
MI18-M_u2 net133 CI1 VSS VSS nch w=0.39u l=0.06u
MI46_0-M_u2 net138 net34 VSS VSS nch w=0.39u l=0.06u
MI46_1-M_u2 net138 net34 VSS VSS nch w=0.39u l=0.06u
MI44-M_u2 net127 net103 VSS VSS nch w=0.37u l=0.06u
MI31-M_u2 S net91 VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 net57 CS VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 CON0 net94 VSS VSS nch w=0.37u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MI45-M_u2 net94 net24 VSS VSS nch w=0.37u l=0.06u
MU26-M_u2 net67 CI0 VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net186 net32 VSS VSS nch w=0.37u l=0.06u
MI41-M_u3 net133 net32 net103 VSS nch w=0.35u l=0.06u
MI42-M_u3 net36 net44 net103 VSS nch w=0.19u l=0.06u
MI47-M_u3 net138 net36 net32 VSS nch w=0.39u l=0.06u
MI40-M_u3 net36 net186 net24 VSS nch w=0.19u l=0.06u
MI48-M_u3 net165 net32 net8 VSS nch w=0.17u l=0.06u
MI43-M_u3 net133 net44 net83 VSS nch w=0.17u l=0.06u
MI29-M_u3 net83 CS net91 VSS nch w=0.21u l=0.06u
MI30-M_u3 net8 net57 net91 VSS nch w=0.21u l=0.06u
MU17-M_u3 net67 net186 net8 VSS nch w=0.17u l=0.06u
MU8-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI39-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI20 VDD net133 net70 VDD pch w=0.52u l=0.06u
MI21 net70 net44 net83 VDD pch w=0.44u l=0.06u
MI32-M_u3 net44 net32 VDD VDD pch w=0.44u l=0.06u
MI49-M_u3 net165 net67 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 CON1 net127 VDD VDD pch w=0.44u l=0.06u
MI18-M_u3 net133 CI1 VDD VDD pch w=0.52u l=0.06u
MI46_0-M_u3 net138 net34 VDD VDD pch w=0.52u l=0.06u
MI46_1-M_u3 net138 net34 VDD VDD pch w=0.52u l=0.06u
MI44-M_u3 net127 net103 VDD VDD pch w=0.44u l=0.06u
MI31-M_u3 S net91 VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 net57 CS VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 CON0 net94 VDD VDD pch w=0.44u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MI45-M_u3 net94 net24 VDD VDD pch w=0.44u l=0.06u
MU26-M_u3 net67 CI0 VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net186 net32 VDD VDD pch w=0.44u l=0.06u
MI41-M_u2 net133 net44 net103 VDD pch w=0.4u l=0.06u
MI42-M_u2 net36 net32 net103 VDD pch w=0.4u l=0.06u
MI47-M_u2 net138 B net32 VDD pch w=0.4u l=0.06u
MI40-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MI48-M_u2 net165 net186 net8 VDD pch w=0.44u l=0.06u
MI43-M_u2 net133 net32 net83 VDD pch w=0.28u l=0.06u
MI29-M_u2 net83 net57 net91 VDD pch w=0.34u l=0.06u
MI30-M_u2 net8 CS net91 VDD pch w=0.4u l=0.06u
MU17-M_u2 net67 net32 net8 VDD pch w=0.28u l=0.06u
MU8-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI39-M_u2 net67 net186 net24 VDD pch w=0.4u l=0.06u
.ends
.subckt FCSICOND2 A B CI0 CI1 CS S CON0 CON1 VDD VSS
MI23 net80 net133 VSS VSS nch w=0.2u l=0.06u
MI22 net83 net32 net80 VSS nch w=0.2u l=0.06u
MI32-M_u2 net44 net32 VSS VSS nch w=0.37u l=0.06u
MI49-M_u2 net165 net67 VSS VSS nch w=0.39u l=0.06u
MI16_0-M_u2 CON1 net157 VSS VSS nch w=0.37u l=0.06u
MI16_1-M_u2 CON1 net157 VSS VSS nch w=0.37u l=0.06u
MI18-M_u2 net133 CI1 VSS VSS nch w=0.39u l=0.06u
MI46_0-M_u2 net138 net34 VSS VSS nch w=0.39u l=0.06u
MI46_1-M_u2 net138 net34 VSS VSS nch w=0.39u l=0.06u
MI51-M_u2 net157 net103 VSS VSS nch w=0.37u l=0.06u
MI31_0-M_u2 S net139 VSS VSS nch w=0.195u l=0.06u
MI31_1-M_u2 S net139 VSS VSS nch w=0.195u l=0.06u
MI27-M_u2 net57 CS VSS VSS nch w=0.39u l=0.06u
MI13_0-M_u2 CON0 net159 VSS VSS nch w=0.37u l=0.06u
MI13_1-M_u2 CON0 net159 VSS VSS nch w=0.37u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 net159 net24 VSS VSS nch w=0.37u l=0.06u
MU26-M_u2 net67 CI0 VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net186 net32 VSS VSS nch w=0.37u l=0.06u
MI41-M_u3 net133 net32 net103 VSS nch w=0.35u l=0.06u
MI42-M_u3 net36 net44 net103 VSS nch w=0.19u l=0.06u
MI47-M_u3 net138 net36 net32 VSS nch w=0.39u l=0.06u
MI40-M_u3 net36 net186 net24 VSS nch w=0.19u l=0.06u
MI48-M_u3 net165 net32 net8 VSS nch w=0.17u l=0.06u
MI43-M_u3 net133 net44 net83 VSS nch w=0.17u l=0.06u
MI29-M_u3 net83 CS net139 VSS nch w=0.21u l=0.06u
MI30-M_u3 net8 net57 net139 VSS nch w=0.21u l=0.06u
MU17-M_u3 net67 net186 net8 VSS nch w=0.17u l=0.06u
MU8-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI39-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI20 VDD net133 net70 VDD pch w=0.52u l=0.06u
MI21 net70 net44 net83 VDD pch w=0.44u l=0.06u
MI32-M_u3 net44 net32 VDD VDD pch w=0.44u l=0.06u
MI49-M_u3 net165 net67 VDD VDD pch w=0.52u l=0.06u
MI16_0-M_u3 CON1 net157 VDD VDD pch w=0.44u l=0.06u
MI16_1-M_u3 CON1 net157 VDD VDD pch w=0.44u l=0.06u
MI18-M_u3 net133 CI1 VDD VDD pch w=0.52u l=0.06u
MI46_0-M_u3 net138 net34 VDD VDD pch w=0.52u l=0.06u
MI46_1-M_u3 net138 net34 VDD VDD pch w=0.52u l=0.06u
MI51-M_u3 net157 net103 VDD VDD pch w=0.44u l=0.06u
MI31_0-M_u3 S net139 VDD VDD pch w=0.26u l=0.06u
MI31_1-M_u3 S net139 VDD VDD pch w=0.26u l=0.06u
MI27-M_u3 net57 CS VDD VDD pch w=0.52u l=0.06u
MI13_0-M_u3 CON0 net159 VDD VDD pch w=0.44u l=0.06u
MI13_1-M_u3 CON0 net159 VDD VDD pch w=0.44u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 net159 net24 VDD VDD pch w=0.44u l=0.06u
MU26-M_u3 net67 CI0 VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net186 net32 VDD VDD pch w=0.44u l=0.06u
MI41-M_u2 net133 net44 net103 VDD pch w=0.4u l=0.06u
MI42-M_u2 net36 net32 net103 VDD pch w=0.4u l=0.06u
MI47-M_u2 net138 B net32 VDD pch w=0.4u l=0.06u
MI40-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MI48-M_u2 net165 net186 net8 VDD pch w=0.44u l=0.06u
MI43-M_u2 net133 net32 net83 VDD pch w=0.28u l=0.06u
MI29-M_u2 net83 net57 net139 VDD pch w=0.34u l=0.06u
MI30-M_u2 net8 CS net139 VDD pch w=0.4u l=0.06u
MU17-M_u2 net67 net32 net8 VDD pch w=0.28u l=0.06u
MU8-M_u2 net34 net36 net32 VDD pch w=0.34u l=0.06u
MI39-M_u2 net67 net186 net24 VDD pch w=0.4u l=0.06u
.ends
.subckt FICIND1 A B CIN S CO VDD VSS
MI16-M_u2 net67 net78 VSS VSS nch w=0.21u l=0.06u
MI18_0-M_u2 net49 net61 VSS VSS nch w=0.39u l=0.06u
MI18_1-M_u2 net49 net61 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 S net55 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net61 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net61 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU28-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU26-M_u2 net78 CIN VSS VSS nch w=0.35u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI13-M_u3 net78 net32 net55 VSS nch w=0.35u l=0.06u
MI17-M_u3 net49 net36 net32 VSS nch w=0.39u l=0.06u
MU17-M_u3 net67 net44 net55 VSS nch w=0.17u l=0.06u
MU8-M_u3 net61 B net32 VSS nch w=0.21u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI16-M_u3 net67 net78 VDD VDD pch w=0.52u l=0.06u
MI18_0-M_u3 net49 net61 VDD VDD pch w=0.52u l=0.06u
MI18_1-M_u3 net49 net61 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 S net55 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net61 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net61 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU28-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU26-M_u3 net78 CIN VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI13-M_u2 net78 net44 net55 VDD pch w=0.44u l=0.06u
MI17-M_u2 net49 B net32 VDD pch w=0.4u l=0.06u
MU17-M_u2 net67 net32 net55 VDD pch w=0.26u l=0.06u
MU8-M_u2 net61 net36 net32 VDD pch w=0.34u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.46u l=0.06u
.ends
.subckt FICIND2 A B CIN S CO VDD VSS
MI16-M_u2 net67 net78 VSS VSS nch w=0.78u l=0.06u
MI18_0-M_u2 net49 net61 VSS VSS nch w=0.39u l=0.06u
MI18_1-M_u2 net49 net61 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 S net55 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 S net55 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net61 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net61 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.78u l=0.06u
MU28_0-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU28_1-M_u2 CO net24 VSS VSS nch w=0.39u l=0.06u
MU26-M_u2 net78 CIN VSS VSS nch w=0.78u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI13-M_u3 net78 net32 net55 VSS nch w=0.345u l=0.06u
MI17-M_u3 net49 net36 net32 VSS nch w=0.33u l=0.06u
MU17-M_u3 net67 net44 net55 VSS nch w=0.165u l=0.06u
MU8-M_u3 net61 B net32 VSS nch w=0.21u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.37u l=0.06u
MI16-M_u3 net67 net78 VDD VDD pch w=1.04u l=0.06u
MI18_0-M_u3 net49 net61 VDD VDD pch w=0.52u l=0.06u
MI18_1-M_u3 net49 net61 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 S net55 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 S net55 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net61 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net61 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=1.04u l=0.06u
MU28_0-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU28_1-M_u3 CO net24 VDD VDD pch w=0.52u l=0.06u
MU26-M_u3 net78 CIN VDD VDD pch w=1.04u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI13-M_u2 net78 net44 net55 VDD pch w=0.445u l=0.06u
MI17-M_u2 net49 B net32 VDD pch w=0.4u l=0.06u
MU17-M_u2 net67 net32 net55 VDD pch w=0.245u l=0.06u
MU8-M_u2 net61 net36 net32 VDD pch w=0.34u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.445u l=0.06u
.ends
.subckt FICOND1 A B CI S CON VDD VSS
MI16_0-M_u2 net61 net69 VSS VSS nch w=0.39u l=0.06u
MI16_1-M_u2 net61 net69 VSS VSS nch w=0.39u l=0.06u
MI17-M_u2 net78 net67 VSS VSS nch w=0.35u l=0.06u
MI13-M_u2 CON net94 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 S net8 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net69 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net69 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MI18-M_u2 net94 net24 VSS VSS nch w=0.39u l=0.06u
MU26-M_u2 net67 CI VSS VSS nch w=0.21u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI14-M_u3 net61 net36 net32 VSS nch w=0.39u l=0.06u
MI15-M_u3 net78 net32 net8 VSS nch w=0.35u l=0.06u
MU17-M_u3 net67 net44 net8 VSS nch w=0.17u l=0.06u
MU8-M_u3 net69 B net32 VSS nch w=0.21u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.35u l=0.06u
MI16_0-M_u3 net61 net69 VDD VDD pch w=0.52u l=0.06u
MI16_1-M_u3 net61 net69 VDD VDD pch w=0.52u l=0.06u
MI17-M_u3 net78 net67 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 CON net94 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 S net8 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net69 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net69 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MI18-M_u3 net94 net24 VDD VDD pch w=0.52u l=0.06u
MU26-M_u3 net67 CI VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI14-M_u2 net61 B net32 VDD pch w=0.4u l=0.06u
MI15-M_u2 net78 net44 net8 VDD pch w=0.44u l=0.06u
MU17-M_u2 net67 net32 net8 VDD pch w=0.26u l=0.06u
MU8-M_u2 net69 net36 net32 VDD pch w=0.34u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.46u l=0.06u
.ends
.subckt FICOND2 A B CI S CON VDD VSS
MI16_0-M_u2 net61 net69 VSS VSS nch w=0.39u l=0.06u
MI16_1-M_u2 net61 net69 VSS VSS nch w=0.39u l=0.06u
MI17-M_u2 net78 net67 VSS VSS nch w=0.345u l=0.06u
MI13_0-M_u2 CON net94 VSS VSS nch w=0.39u l=0.06u
MI13_1-M_u2 CON net94 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 S net8 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 S net8 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net69 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net69 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.78u l=0.06u
MU28-M_u2 net94 net24 VSS VSS nch w=0.39u l=0.06u
MU26-M_u2 net67 CI VSS VSS nch w=0.78u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI14-M_u3 net61 net36 net32 VSS nch w=0.33u l=0.06u
MI15-M_u3 net78 net32 net8 VSS nch w=0.345u l=0.06u
MU17-M_u3 net67 net44 net8 VSS nch w=0.165u l=0.06u
MU8-M_u3 net69 B net32 VSS nch w=0.21u l=0.06u
MU27-M_u3 net36 net44 net24 VSS nch w=0.19u l=0.06u
MU25-M_u3 net67 net32 net24 VSS nch w=0.37u l=0.06u
MI16_0-M_u3 net61 net69 VDD VDD pch w=0.52u l=0.06u
MI16_1-M_u3 net61 net69 VDD VDD pch w=0.52u l=0.06u
MI17-M_u3 net78 net67 VDD VDD pch w=0.52u l=0.06u
MI13_0-M_u3 CON net94 VDD VDD pch w=0.52u l=0.06u
MI13_1-M_u3 CON net94 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 S net8 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 S net8 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net69 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net69 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=1.04u l=0.06u
MU28-M_u3 net94 net24 VDD VDD pch w=0.39u l=0.06u
MU26-M_u3 net67 CI VDD VDD pch w=1.04u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI14-M_u2 net61 B net32 VDD pch w=0.4u l=0.06u
MI15-M_u2 net78 net44 net8 VDD pch w=0.445u l=0.06u
MU17-M_u2 net67 net32 net8 VDD pch w=0.245u l=0.06u
MU8-M_u2 net69 net36 net32 VDD pch w=0.34u l=0.06u
MU27-M_u2 net36 net32 net24 VDD pch w=0.4u l=0.06u
MU25-M_u2 net67 net44 net24 VDD pch w=0.445u l=0.06u
.ends
.subckt FIICOND1 A B C S CON0 CON1 VDD VSS
MI2-M_u4 XI2-net6 B VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 CON0 A XI2-net6 VSS nch w=0.39u l=0.06u
MI17-M_u4 CON1 A VSS VSS nch w=0.39u l=0.06u
MI17-M_u3 CON1 B VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net77 net67 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MU18-M_u2 S net8 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU26_0-M_u2 net67 C VSS VSS nch w=0.39u l=0.06u
MU26_1-M_u2 net67 C VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net77 net32 net8 VSS nch w=0.265u l=0.06u
MU17-M_u3 net67 net44 net8 VSS nch w=0.19u l=0.06u
MI14-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.395u l=0.06u
MI2-M_u2 CON0 B VDD VDD pch w=0.52u l=0.06u
MI2-M_u1 CON0 A VDD VDD pch w=0.52u l=0.06u
MI17-M_u1 XI17-net8 B VDD VDD pch w=0.52u l=0.06u
MI17-M_u2 CON1 A XI17-net8 VDD pch w=0.52u l=0.06u
MI16-M_u3 net77 net67 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MU18-M_u3 S net8 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU26_0-M_u3 net67 C VDD VDD pch w=0.52u l=0.06u
MU26_1-M_u3 net67 C VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI15-M_u2 net77 net44 net8 VDD pch w=0.44u l=0.06u
MU17-M_u2 net67 net32 net8 VDD pch w=0.335u l=0.06u
MI14-M_u2 net34 net36 net32 VDD pch w=0.32u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.4u l=0.06u
.ends
.subckt FIICOND2 A B C S CON0 CON1 VDD VSS
MI2_0-M_u4 XI2_0-net6 B VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u3 CON0 A XI2_0-net6 VSS nch w=0.39u l=0.06u
MI2_1-M_u4 XI2_1-net6 B VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u3 CON0 A XI2_1-net6 VSS nch w=0.39u l=0.06u
MI17_0-M_u4 CON1 A VSS VSS nch w=0.39u l=0.06u
MI17_0-M_u3 CON1 B VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u4 CON1 A VSS VSS nch w=0.39u l=0.06u
MI17_1-M_u3 CON1 B VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net77 net67 VSS VSS nch w=0.39u l=0.06u
MI12_0-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MI12_1-M_u2 net64 net34 VSS VSS nch w=0.39u l=0.06u
MU18_0-M_u2 S net56 VSS VSS nch w=0.39u l=0.06u
MU18_1-M_u2 S net56 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net34 A VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU26_0-M_u2 net67 C VSS VSS nch w=0.39u l=0.06u
MU26_1-M_u2 net67 C VSS VSS nch w=0.39u l=0.06u
MU4-M_u2 net44 net32 VSS VSS nch w=0.39u l=0.06u
MI15-M_u3 net77 net32 net56 VSS nch w=0.265u l=0.06u
MU17-M_u3 net67 net44 net56 VSS nch w=0.21u l=0.06u
MI14-M_u3 net34 B net32 VSS nch w=0.21u l=0.06u
MI13-M_u3 net64 net36 net32 VSS nch w=0.395u l=0.06u
MI2_0-M_u2 CON0 B VDD VDD pch w=0.52u l=0.06u
MI2_0-M_u1 CON0 A VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u2 CON0 B VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u1 CON0 A VDD VDD pch w=0.52u l=0.06u
MI17_0-M_u1 XI17_0-net8 B VDD VDD pch w=0.52u l=0.06u
MI17_0-M_u2 CON1 A XI17_0-net8 VDD pch w=0.52u l=0.06u
MI17_1-M_u1 XI17_1-net8 B VDD VDD pch w=0.52u l=0.06u
MI17_1-M_u2 CON1 A XI17_1-net8 VDD pch w=0.52u l=0.06u
MI16-M_u3 net77 net67 VDD VDD pch w=0.52u l=0.06u
MI12_0-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MI12_1-M_u3 net64 net34 VDD VDD pch w=0.52u l=0.06u
MU18_0-M_u3 S net56 VDD VDD pch w=0.52u l=0.06u
MU18_1-M_u3 S net56 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net34 A VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.52u l=0.06u
MU26_0-M_u3 net67 C VDD VDD pch w=0.52u l=0.06u
MU26_1-M_u3 net67 C VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 net44 net32 VDD VDD pch w=0.52u l=0.06u
MI15-M_u2 net77 net44 net56 VDD pch w=0.44u l=0.06u
MU17-M_u2 net67 net32 net56 VDD pch w=0.335u l=0.06u
MI14-M_u2 net34 net36 net32 VDD pch w=0.32u l=0.06u
MI13-M_u2 net64 B net32 VDD pch w=0.4u l=0.06u
.ends
.subckt GAN2D1 A1 A2 Z VDD VSS
MI2 VSS net6 VSS VSS nch w=0.39u l=0.06u
M_u3-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net6 A1 X_u2-net6 VSS nch w=0.39u l=0.06u
MI1 VDD net6 VDD VDD pch w=0.52u l=0.06u
M_u3-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net6 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net6 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GAN2D2 A1 A2 Z VDD VSS
M_u3_0-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net010 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u4 X_u2-net6 A2 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net010 A1 X_u2-net6 VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net010 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u2 net010 A2 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u1 net010 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GAOI21D1 A1 A2 B ZN VDD VSS
MI2 ZN A1 net27 VSS nch w=0.39u l=0.06u
MI3 net27 A2 VSS VSS nch w=0.39u l=0.06u
MI8 ZN B VSS VSS nch w=0.39u l=0.06u
M_u7 ZN B VSS VSS nch w=0.39u l=0.06u
MI7 net13 B VDD VDD pch w=0.52u l=0.06u
M_u4 net13 A2 ZN VDD pch w=0.52u l=0.06u
M_u2 net13 B VDD VDD pch w=0.52u l=0.06u
M_u3 net13 A1 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt GAOI21D2 A1 A2 B ZN VDD VSS
MI20 net024 A2 VSS VSS nch w=0.39u l=0.06u
MI19 ZN A1 net024 VSS nch w=0.39u l=0.06u
MI2 ZN A1 net026 VSS nch w=0.39u l=0.06u
MI12 net026 A2 VSS VSS nch w=0.39u l=0.06u
MI11_0 ZN B VSS VSS nch w=0.39u l=0.06u
MI11_1 ZN B VSS VSS nch w=0.39u l=0.06u
MI15 ZN A2 net74 VDD pch w=1.04u l=0.06u
M_u2 net74 B VDD VDD pch w=1.04u l=0.06u
MI16 ZN A1 net74 VDD pch w=1.04u l=0.06u
.ends
.subckt GAOI22D1 A1 A2 B1 B2 ZN VDD VSS
MI3 ZN B1 net29 VSS nch w=0.39u l=0.06u
MI8 net29 B2 VSS VSS nch w=0.39u l=0.06u
MI9 ZN A1 net23 VSS nch w=0.39u l=0.06u
MI10 net23 A2 VSS VSS nch w=0.39u l=0.06u
M_u2 net20 A1 ZN VDD pch w=0.52u l=0.06u
M_u4 VDD B1 net20 VDD pch w=0.52u l=0.06u
M_u3 net20 A2 ZN VDD pch w=0.52u l=0.06u
M_u5 VDD B2 net20 VDD pch w=0.52u l=0.06u
.ends
.subckt GBUFFD1 I Z VDD VSS
MI1-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net6 I VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net6 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GBUFFD2 I Z VDD VSS
MI1-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
M_u3_0-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GBUFFD3 I Z VDD VSS
M_u3_0-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GBUFFD4 I Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GBUFFD8 I Z VDD VSS
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_3-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u7_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_3-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDCAP VDD VSS
MI2 VSS net8 VSS VSS nch w=0.39u l=0.06u
M_u2 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI1 VDD net6 VDD VDD pch w=0.52u l=0.06u
M_u1 net6 net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDCAP10 VDD VSS
MI38 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI37 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI36 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI35 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI34 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI33 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI32 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI31 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI30 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI29 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI28 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI27 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI14 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI9 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI10 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI7 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI5 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI3 VDD net106 VDD VDD pch w=0.52u l=0.06u
MI1 VDD net106 VDD VDD pch w=0.52u l=0.06u
M_u1 net106 net79 VDD VDD pch w=0.52u l=0.06u
MI25 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI26 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI24 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI23 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI22 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI21 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI20 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI19 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI18 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI4 VSS net79 VSS VSS nch w=0.39u l=0.06u
M_u2 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI13 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI8 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI17 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI16 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI15 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI2 VSS net79 VSS VSS nch w=0.39u l=0.06u
MI12 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI11 net79 net106 VSS VSS nch w=0.39u l=0.06u
MI6 VSS net79 VSS VSS nch w=0.39u l=0.06u
.ends
.subckt GDCAP2 VDD VSS
MI6 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI2 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI4 VSS net8 VSS VSS nch w=0.39u l=0.06u
M_u2 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI5 net6 net8 VDD VDD pch w=0.52u l=0.06u
MI3 VDD net6 VDD VDD pch w=0.52u l=0.06u
MI1 VDD net6 VDD VDD pch w=0.52u l=0.06u
M_u1 net6 net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDCAP3 VDD VSS
MI7 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI8 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI6 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI2 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI4 VSS net8 VSS VSS nch w=0.39u l=0.06u
M_u2 net8 net6 VSS VSS nch w=0.39u l=0.06u
MI9 net6 net8 VDD VDD pch w=0.52u l=0.06u
MI10 net6 net8 VDD VDD pch w=0.52u l=0.06u
MI5 VDD net6 VDD VDD pch w=0.52u l=0.06u
MI3 VDD net6 VDD VDD pch w=0.52u l=0.06u
MI1 VDD net6 VDD VDD pch w=0.52u l=0.06u
M_u1 net6 net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDCAP4 VDD VSS
MI11 net8 net051 VSS VSS nch w=0.39u l=0.06u
MI12 net8 net051 VSS VSS nch w=0.39u l=0.06u
MI13 net8 net051 VSS VSS nch w=0.39u l=0.06u
MI8 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI6 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI2 VSS net8 VSS VSS nch w=0.39u l=0.06u
MI4 VSS net8 VSS VSS nch w=0.39u l=0.06u
M_u2 net8 net051 VSS VSS nch w=0.39u l=0.06u
MI14 net051 net8 VDD VDD pch w=0.52u l=0.06u
MI9 net051 net8 VDD VDD pch w=0.52u l=0.06u
MI10 net051 net8 VDD VDD pch w=0.52u l=0.06u
MI7 VDD net051 VDD VDD pch w=0.52u l=0.06u
MI5 VDD net051 VDD VDD pch w=0.52u l=0.06u
MI3 VDD net051 VDD VDD pch w=0.52u l=0.06u
MI1 VDD net051 VDD VDD pch w=0.52u l=0.06u
M_u1 net051 net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDFCNQD1 D CP CDN Q VDD VSS
MI4 net52 D VSS VSS nch w=0.39u l=0.06u
MI15 d1 CP d2 VSS nch w=0.39u l=0.06u
MI5 d0 net071 net52 VSS nch w=0.39u l=0.06u
MI18 net101 net069 d2 VSS nch w=0.39u l=0.06u
MI47 d0 CP net59 VSS nch w=0.39u l=0.06u
MI48 net59 d1 net62 VSS nch w=0.39u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.39u l=0.06u
MI23-M_u4 XI23-net6 d2 VSS VSS nch w=0.39u l=0.06u
MI23-M_u3 d3 CDN XI23-net6 VSS nch w=0.39u l=0.06u
MI25-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net071 CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net101 d3 VSS VSS nch w=0.39u l=0.06u
MI29-M_u2 net069 CP VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI23-M_u1 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net071 CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net101 d3 VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 net069 CP VDD VDD pch w=0.52u l=0.06u
MI6 d0 CP net85 VDD pch w=0.52u l=0.06u
MI7 net85 D VDD VDD pch w=0.52u l=0.06u
MI16 d1 net069 d2 VDD pch w=0.52u l=0.06u
MI17 net101 CP d2 VDD pch w=0.52u l=0.06u
MI45 d0 net071 net98 VDD pch w=0.52u l=0.06u
MI43 net98 d1 VDD VDD pch w=0.52u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GDFQD1 D CP Q VDD VSS
MI4 net43 D VSS VSS nch w=0.39u l=0.06u
MI5 d0 net060 net43 VSS nch w=0.39u l=0.06u
MI47 d0 CP net50 VSS nch w=0.39u l=0.06u
MI48 net50 d1 VSS VSS nch w=0.39u l=0.06u
MI60 d2 net058 net052 VSS nch w=0.39u l=0.06u
MI50 d1 CP d2 VSS nch w=0.39u l=0.06u
MI62-M_u2 net052 net67 VSS VSS nch w=0.39u l=0.06u
MI59-M_u2 net058 CP VSS VSS nch w=0.39u l=0.06u
MI31-M_u2 net060 CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q net67 VSS VSS nch w=0.39u l=0.06u
MI53-M_u2 net67 d2 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI62-M_u3 net052 net67 VDD VDD pch w=0.52u l=0.06u
MI59-M_u3 net058 CP VDD VDD pch w=0.52u l=0.06u
MI31-M_u3 net060 CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q net67 VDD VDD pch w=0.52u l=0.06u
MI53-M_u3 net67 d2 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI6 d0 CP net66 VDD pch w=0.52u l=0.06u
MI7 net66 D VDD VDD pch w=0.52u l=0.06u
MI61 d2 CP net052 VDD pch w=0.52u l=0.06u
MI52 d1 net058 d2 VDD pch w=0.52u l=0.06u
MI45 d0 net060 net84 VDD pch w=0.52u l=0.06u
MI43 net84 d1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GFILL VDD VSS
MI2 net014 net8 net014 VSS nch w=0.39u l=0.06u
M_u2 net8 net6 net014 VSS nch w=0.39u l=0.06u
MI1 net024 net6 net024 VDD pch w=0.52u l=0.06u
M_u1 net6 net8 net024 VDD pch w=0.52u l=0.06u
.ends
.subckt GFILL10 VDD VSS
MI38 net0176 net106 net0176 VDD pch w=0.52u l=0.06u
MI37 net0173 net106 net0173 VDD pch w=0.52u l=0.06u
MI36 net0182 net106 net0182 VDD pch w=0.52u l=0.06u
MI35 net0179 net106 net0179 VDD pch w=0.52u l=0.06u
MI34 net0185 net106 net0185 VDD pch w=0.52u l=0.06u
MI33 net0188 net106 net0188 VDD pch w=0.52u l=0.06u
MI32 net106 net79 net0173 VDD pch w=0.52u l=0.06u
MI31 net106 net79 net0176 VDD pch w=0.52u l=0.06u
MI30 net106 net79 net0179 VDD pch w=0.52u l=0.06u
MI29 net106 net79 net0182 VDD pch w=0.52u l=0.06u
MI28 net106 net79 net0185 VDD pch w=0.52u l=0.06u
MI27 net106 net79 net0188 VDD pch w=0.52u l=0.06u
MI14 net106 net79 net0191 VDD pch w=0.52u l=0.06u
MI9 net106 net79 net0194 VDD pch w=0.52u l=0.06u
MI10 net106 net79 net0197 VDD pch w=0.52u l=0.06u
MI7 net0191 net106 net0191 VDD pch w=0.52u l=0.06u
MI5 net0197 net106 net0197 VDD pch w=0.52u l=0.06u
MI3 net0194 net106 net0194 VDD pch w=0.52u l=0.06u
MI1 net0212 net106 net0212 VDD pch w=0.52u l=0.06u
M_u1 net106 net79 net0212 VDD pch w=0.52u l=0.06u
MI25 net0214 net79 net0214 VSS nch w=0.39u l=0.06u
MI26 net0217 net79 net0217 VSS nch w=0.39u l=0.06u
MI24 net0220 net79 net0220 VSS nch w=0.39u l=0.06u
MI23 net0223 net79 net0223 VSS nch w=0.39u l=0.06u
MI22 net0226 net79 net0226 VSS nch w=0.39u l=0.06u
MI21 net0229 net79 net0229 VSS nch w=0.39u l=0.06u
MI20 net79 net106 net0214 VSS nch w=0.39u l=0.06u
MI19 net79 net106 net0217 VSS nch w=0.39u l=0.06u
MI18 net79 net106 net0220 VSS nch w=0.39u l=0.06u
MI4 net0241 net79 net0241 VSS nch w=0.39u l=0.06u
M_u2 net79 net106 net0262 VSS nch w=0.39u l=0.06u
MI13 net79 net106 net0250 VSS nch w=0.39u l=0.06u
MI8 net0250 net79 net0250 VSS nch w=0.39u l=0.06u
MI17 net79 net106 net0226 VSS nch w=0.39u l=0.06u
MI16 net79 net106 net0229 VSS nch w=0.39u l=0.06u
MI15 net79 net106 net0223 VSS nch w=0.39u l=0.06u
MI2 net0262 net79 net0262 VSS nch w=0.39u l=0.06u
MI12 net79 net106 net0271 VSS nch w=0.39u l=0.06u
MI11 net79 net106 net0241 VSS nch w=0.39u l=0.06u
MI6 net0271 net79 net0271 VSS nch w=0.39u l=0.06u
.ends
.subckt GFILL2 VDD VSS
MI6 net8 net6 net024 VSS nch w=0.39u l=0.06u
MI2 net021 net8 net021 VSS nch w=0.39u l=0.06u
MI4 net024 net8 net024 VSS nch w=0.39u l=0.06u
M_u2 net8 net6 net021 VSS nch w=0.39u l=0.06u
MI5 net6 net8 net031 VDD pch w=0.52u l=0.06u
MI3 net031 net6 net031 VDD pch w=0.52u l=0.06u
MI1 net040 net6 net040 VDD pch w=0.52u l=0.06u
M_u1 net6 net8 net040 VDD pch w=0.52u l=0.06u
.ends
.subckt GFILL3 VDD VSS
MI7 net8 net6 net068 VSS nch w=0.39u l=0.06u
MI8 net8 net6 net062 VSS nch w=0.39u l=0.06u
MI6 net062 net8 net062 VSS nch w=0.39u l=0.06u
MI2 net065 net8 net065 VSS nch w=0.39u l=0.06u
MI4 net068 net8 net068 VSS nch w=0.39u l=0.06u
M_u2 net8 net6 net065 VSS nch w=0.39u l=0.06u
MI9 net6 net8 net075 VDD pch w=0.52u l=0.06u
MI10 net6 net8 net078 VDD pch w=0.52u l=0.06u
MI5 net078 net6 net078 VDD pch w=0.52u l=0.06u
MI3 net075 net6 net075 VDD pch w=0.52u l=0.06u
MI1 net090 net6 net090 VDD pch w=0.52u l=0.06u
M_u1 net6 net8 net090 VDD pch w=0.52u l=0.06u
.ends
.subckt GFILL4 VDD VSS
MI11 net8 net051 net040 VSS nch w=0.39u l=0.06u
MI12 net8 net051 net034 VSS nch w=0.39u l=0.06u
MI13 net8 net051 net031 VSS nch w=0.39u l=0.06u
MI8 net031 net8 net031 VSS nch w=0.39u l=0.06u
MI6 net034 net8 net034 VSS nch w=0.39u l=0.06u
MI2 net037 net8 net037 VSS nch w=0.39u l=0.06u
MI4 net040 net8 net040 VSS nch w=0.39u l=0.06u
M_u2 net8 net051 net037 VSS nch w=0.39u l=0.06u
MI14 net051 net8 net047 VDD pch w=0.52u l=0.06u
MI9 net051 net8 net050 VDD pch w=0.52u l=0.06u
MI10 net051 net8 net053 VDD pch w=0.52u l=0.06u
MI7 net047 net051 net047 VDD pch w=0.52u l=0.06u
MI5 net053 net051 net053 VDD pch w=0.52u l=0.06u
MI3 net050 net051 net050 VDD pch w=0.52u l=0.06u
MI1 net068 net051 net068 VDD pch w=0.52u l=0.06u
M_u1 net051 net8 net068 VDD pch w=0.52u l=0.06u
.ends
.subckt GINVD1 I ZN VDD VSS
MI2 VSS I VSS VSS nch w=0.39u l=0.06u
MU1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI1 VDD I VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GINVD2 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GINVD3 I ZN VDD VSS
MI2 VSS I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MI1 VDD I VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GINVD4 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GINVD8 I ZN VDD VSS
MU1_0-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_3-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_4-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_5-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_6-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_7-M_u2 ZN I VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_3-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_4-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_5-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_6-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
MU1_7-M_u3 ZN I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GMUX2D1 I0 I1 S Z VDD VSS
MI21 net032 I0 VSS VSS nch w=0.39u l=0.06u
MI24 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI25 net28 S net037 VSS nch w=0.39u l=0.06u
MI20 net28 net6 net032 VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI17 net030 I0 VDD VDD pch w=0.52u l=0.06u
MI27 net28 net6 net025 VDD pch w=0.52u l=0.06u
MI28 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI18 net28 S net030 VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GMUX2D2 I0 I1 S Z VDD VSS
MI31 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI21 net032 I0 VSS VSS nch w=0.39u l=0.06u
MI24 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI25 net28 S net037 VSS nch w=0.39u l=0.06u
MI20 net28 net6 net032 VSS nch w=0.39u l=0.06u
MI29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI17 net030 I0 VDD VDD pch w=0.52u l=0.06u
MI30 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI27 net28 net6 net025 VDD pch w=0.52u l=0.06u
MI28 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI18 net28 S net030 VDD pch w=0.52u l=0.06u
MI29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GMUX2ND1 I0 I1 S ZN VDD VSS
MI31 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI21 net032 I0 VSS VSS nch w=0.39u l=0.06u
MI24 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI25 net28 S net037 VSS nch w=0.39u l=0.06u
MI20 net28 net6 net032 VSS nch w=0.39u l=0.06u
MI29-M_u2 ZN net082 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 net082 net28 VSS VSS nch w=0.39u l=0.06u
MI17 net030 I0 VDD VDD pch w=0.52u l=0.06u
MI27 net28 net6 net025 VDD pch w=0.52u l=0.06u
MI28 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI30 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI18 net28 S net030 VDD pch w=0.52u l=0.06u
MI29-M_u3 ZN net082 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 net082 net28 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GMUX2ND2 I0 I1 S ZN VDD VSS
MI21 net032 I0 VSS VSS nch w=0.39u l=0.06u
MI24 net037 I1 VSS VSS nch w=0.39u l=0.06u
MI25 net28 S net037 VSS nch w=0.39u l=0.06u
MI20 net28 net6 net032 VSS nch w=0.39u l=0.06u
MI29-M_u2 ZN net053 VSS VSS nch w=0.39u l=0.06u
MI30-M_u2 net053 net28 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net6 S VSS VSS nch w=0.39u l=0.06u
MU29-M_u2 ZN net053 VSS VSS nch w=0.39u l=0.06u
MI17 net030 I0 VDD VDD pch w=0.52u l=0.06u
MI27 net28 net6 net025 VDD pch w=0.52u l=0.06u
MI28 net025 I1 VDD VDD pch w=0.52u l=0.06u
MI18 net28 S net030 VDD pch w=0.52u l=0.06u
MI29-M_u3 ZN net053 VDD VDD pch w=0.52u l=0.06u
MI30-M_u3 net053 net28 VDD VDD pch w=0.52u l=0.06u
MI15-M_u3 net6 S VDD VDD pch w=0.52u l=0.06u
MU29-M_u3 ZN net053 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GND2D1 A1 A2 ZN VDD VSS
MI2-M_u4 XI2-net6 A1 VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 ZN A2 XI2-net6 VSS nch w=0.39u l=0.06u
MI2-M_u2 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2-M_u1 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GND2D2 A1 A2 ZN VDD VSS
MI1_0-M_u4 XI1_0-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1_0-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1_1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1_1-net6 VSS nch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GND2D3 A1 A2 ZN VDD VSS
MI1_0-M_u4 XI1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 ZN A1 XI1-net6 VSS nch w=0.39u l=0.06u
MI1_1-M_u4 XI1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 ZN A1 XI1-net6 VSS nch w=0.39u l=0.06u
MI1_2-M_u4 XI1-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 ZN A1 XI1-net6 VSS nch w=0.39u l=0.06u
MI1_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GND2D4 A1 A2 ZN VDD VSS
MI3_0-M_u4 XI3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u3 ZN A1 XI3-net6 VSS nch w=0.39u l=0.06u
MI3_1-M_u4 XI3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u3 ZN A1 XI3-net6 VSS nch w=0.39u l=0.06u
MI3_2-M_u4 XI3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI3_2-M_u3 ZN A1 XI3-net6 VSS nch w=0.39u l=0.06u
MI3_3-M_u4 XI3-net6 A2 VSS VSS nch w=0.39u l=0.06u
MI3_3-M_u3 ZN A1 XI3-net6 VSS nch w=0.39u l=0.06u
MI3_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI3_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI3_2-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI3_2-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI3_3-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI3_3-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GND3D1 A1 A2 A3 ZN VDD VSS
M_u3_0 ZN A1 VDD VDD pch w=0.52u l=0.06u
M_u3_1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI9 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI8 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI7_0 net40 A1 VSS VSS nch w=0.39u l=0.06u
MI7_1 net40 A1 VSS VSS nch w=0.39u l=0.06u
MI6 net41 A2 net40 VSS nch w=0.39u l=0.06u
M_u4 ZN A3 net41 VSS nch w=0.39u l=0.06u
.ends
.subckt GND3D2 A1 A2 A3 ZN VDD VSS
MI2_0-M_u4 ZN A1 XI2_0-net10 VSS nch w=0.39u l=0.06u
MI2_0-M_u5 XI2_0-net10 A2 XI2_0-net13 VSS nch w=0.39u l=0.06u
MI2_0-M_u6 XI2_0-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u4 ZN A1 XI2_1-net10 VSS nch w=0.39u l=0.06u
MI2_1-M_u5 XI2_1-net10 A2 XI2_1-net13 VSS nch w=0.39u l=0.06u
MI2_1-M_u6 XI2_1-net13 A3 VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI2_0-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2_0-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u3 ZN A3 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u1 ZN A1 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u2 ZN A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GNR2D1 A1 A2 ZN VDD VSS
MI2-M_u4 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI2-M_u1 XI2-net8 A1 VDD VDD pch w=0.52u l=0.06u
MI2-M_u2 ZN A2 XI2-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt GNR2D2 A1 A2 ZN VDD VSS
MI2_0-M_u4 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u3 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u4 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u3 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u1 XI2_0-net8 A1 VDD VDD pch w=0.52u l=0.06u
MI2_0-M_u2 ZN A2 XI2_0-net8 VDD pch w=0.52u l=0.06u
MI2_1-M_u1 XI2_1-net8 A1 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u2 ZN A2 XI2_1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt GNR3D1 A1 A2 A3 ZN VDD VSS
M_u4_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI2 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI3 ZN A1 VSS VSS nch w=0.39u l=0.06u
M_u1_0 net034 A3 VDD VDD pch w=0.52u l=0.06u
M_u1_1 net034 A3 VDD VDD pch w=0.52u l=0.06u
MI4 net031 A2 net034 VDD pch w=0.52u l=0.06u
MI5 ZN A1 net031 VDD pch w=0.52u l=0.06u
.ends
.subckt GNR3D2 A1 A2 A3 ZN VDD VSS
M_u4_0 ZN A3 VSS VSS nch w=0.39u l=0.06u
M_u4_1 ZN A3 VSS VSS nch w=0.39u l=0.06u
MI7_0 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI7_1 ZN A1 VSS VSS nch w=0.39u l=0.06u
MI6_0 ZN A2 VSS VSS nch w=0.39u l=0.06u
MI6_1 ZN A2 VSS VSS nch w=0.39u l=0.06u
M_u1 net034 A3 VDD VDD pch w=1.04u l=0.06u
MI25 ZN A1 net031 VDD pch w=1.04u l=0.06u
MI24 net031 A2 net034 VDD pch w=1.04u l=0.06u
.ends
.subckt GOAI21D1 A1 A2 B ZN VDD VSS
M_u2 ZN A1 net15 VSS nch w=0.39u l=0.06u
M_u3 ZN A2 net15 VSS nch w=0.39u l=0.06u
M_u4_0 net15 B VSS VSS nch w=0.39u l=0.06u
M_u4_1 net15 B VSS VSS nch w=0.39u l=0.06u
M_u9_0 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_1 ZN B VDD VDD pch w=0.52u l=0.06u
MI16-MI12 ZN A1 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GOAI21D2 A1 A2 B ZN VDD VSS
MI0 ZN A1 net15 VSS nch w=0.78u l=0.06u
M_u3 ZN A2 net15 VSS nch w=0.78u l=0.06u
MI1 net15 B VSS VSS nch w=0.78u l=0.06u
M_u9_0 ZN B VDD VDD pch w=0.52u l=0.06u
M_u9_1 ZN B VDD VDD pch w=0.52u l=0.06u
MI16_0-MI12 ZN A1 XI16_0-net11 VDD pch w=0.52u l=0.06u
MI16_0-MI13 XI16_0-net11 A2 VDD VDD pch w=0.52u l=0.06u
MI16_1-MI12 ZN A1 XI16_1-net11 VDD pch w=0.52u l=0.06u
MI16_1-MI13 XI16_1-net11 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GOR2D1 A1 A2 Z VDD VSS
MI2 VSS net7 VSS VSS nch w=0.39u l=0.06u
MU1-M_u2 Z net7 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u4 net7 A1 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u3 net7 A2 VSS VSS nch w=0.39u l=0.06u
MI1 VDD net7 VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 Z net7 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u2 net7 A1 X_u7-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt GOR2D2 A1 A2 Z VDD VSS
MU1_0-M_u2 Z net9 VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 Z net9 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u4 net9 A1 VSS VSS nch w=0.39u l=0.06u
M_u7-M_u3 net9 A2 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u3 Z net9 VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 Z net9 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u1 X_u7-net8 A2 VDD VDD pch w=0.52u l=0.06u
M_u7-M_u2 net9 A1 X_u7-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt GSDFCNQD1 SI D SE CP CDN Q VDD VSS
MI169 net077 net065 net080 VSS nch w=0.39u l=0.06u
MI36 net085 SI VSS VSS nch w=0.39u l=0.06u
MI35 net077 SE net085 VSS nch w=0.39u l=0.06u
MI34 d0 net071 net077 VSS nch w=0.39u l=0.06u
MI81 net080 D VSS VSS nch w=0.39u l=0.06u
MI45 d2 CP d1 VSS nch w=0.39u l=0.06u
MI18 net101 net069 d2 VSS nch w=0.39u l=0.06u
MI49 net62 CDN VSS VSS nch w=0.39u l=0.06u
MI40 d0 CP net099 VSS nch w=0.39u l=0.06u
MI39 net099 d1 net62 VSS nch w=0.39u l=0.06u
MI23-M_u4 XI23-net6 d2 VSS VSS nch w=0.39u l=0.06u
MI23-M_u3 d3 CDN XI23-net6 VSS nch w=0.39u l=0.06u
MI29-M_u2 net069 CP VSS VSS nch w=0.39u l=0.06u
MI28-M_u2 net071 CP VSS VSS nch w=0.39u l=0.06u
MI27-M_u2 Q d3 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 net065 SE VSS VSS nch w=0.39u l=0.06u
MI25-M_u2 d1 d0 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net101 d3 VSS VSS nch w=0.39u l=0.06u
MI32 net072 SE net080 VDD pch w=0.52u l=0.06u
MI30 net072 net065 net055 VDD pch w=0.52u l=0.06u
MI31 net080 D VDD VDD pch w=0.52u l=0.06u
MI75 net055 SI VDD VDD pch w=0.52u l=0.06u
MI33 d0 CP net072 VDD pch w=0.52u l=0.06u
MI23-M_u2 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI23-M_u1 d3 CDN VDD VDD pch w=0.52u l=0.06u
MI29-M_u3 net069 CP VDD VDD pch w=0.52u l=0.06u
MI28-M_u3 net071 CP VDD VDD pch w=0.52u l=0.06u
MI27-M_u3 Q d3 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 net065 SE VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net101 d3 VDD VDD pch w=0.52u l=0.06u
MI43 d2 net069 d1 VDD pch w=0.52u l=0.06u
MI17 net101 CP d2 VDD pch w=0.52u l=0.06u
MI37 net98 d1 VDD VDD pch w=0.52u l=0.06u
MI38 d0 net071 net98 VDD pch w=0.52u l=0.06u
MI44 net98 CDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GTIEH Z VDD VSS
MI1 net6 net6 VSS VSS nch w=0.39u l=0.06u
M_u2 net6 net6 VSS VSS nch w=0.39u l=0.06u
MI0 Z net6 VDD VDD pch w=0.52u l=0.06u
M_u1 Z net6 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GTIEL ZN VDD VSS
MI1 ZN net6 VSS VSS nch w=0.39u l=0.06u
M_u2 ZN net6 VSS VSS nch w=0.39u l=0.06u
MI0 net6 net6 VDD VDD pch w=0.52u l=0.06u
M_u1 net6 net6 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GXNR2D1 A1 A2 ZN VDD VSS
MI21 net016 net4 VSS VSS nch w=0.39u l=0.06u
MI20 net14 net10 net016 VSS nch w=0.39u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.39u l=0.06u
M_u6-M_u3 net4 A1 net14 VSS nch w=0.39u l=0.06u
MI18 net14 A1 net025 VDD pch w=0.52u l=0.06u
MI17 net025 net4 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.52u l=0.06u
M_u6-M_u2 net4 net10 net14 VDD pch w=0.52u l=0.06u
.ends
.subckt GXNR2D2 A1 A2 ZN VDD VSS
MI21 net019 net4 VSS VSS nch w=0.39u l=0.06u
MI20 net14 net10 net019 VSS nch w=0.39u l=0.06u
MI2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.39u l=0.06u
M_u6-M_u3 net4 A1 net14 VSS nch w=0.39u l=0.06u
MI18 net14 A1 net028 VDD pch w=0.52u l=0.06u
MI17 net028 net4 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.52u l=0.06u
M_u6-M_u2 net4 net10 net14 VDD pch w=0.52u l=0.06u
.ends
.subckt GXOR2D1 A1 A2 Z VDD VSS
MI21 net015 net4 VSS VSS nch w=0.39u l=0.06u
MI20 net14 A1 net015 VSS nch w=0.39u l=0.06u
M_u6-M_u3 net4 net10 net14 VSS nch w=0.39u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.39u l=0.06u
MI18 net14 net10 net024 VDD pch w=0.52u l=0.06u
MI17 net024 net4 VDD VDD pch w=0.52u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.52u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt GXOR2D2 A1 A2 Z VDD VSS
MI21 net022 net23 VSS VSS nch w=0.39u l=0.06u
MI20 net27 A1 net022 VSS nch w=0.39u l=0.06u
MI3-M_u2 net23 A2 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net23 A2 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net17 A1 VSS VSS nch w=0.39u l=0.06u
M_u6-M_u3 net23 net17 net27 VSS nch w=0.39u l=0.06u
MI17 net027 net23 VDD VDD pch w=0.52u l=0.06u
MI18 net27 net17 net027 VDD pch w=0.52u l=0.06u
MI3-M_u3 net23 A2 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net23 A2 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net17 A1 VDD VDD pch w=0.52u l=0.06u
M_u6-M_u2 net23 A1 net27 VDD pch w=0.52u l=0.06u
.ends
.subckt HA1D0 A B S CO VDD VSS
MU9-M_u4 XU9-net6 B VSS VSS nch w=0.195u l=0.06u
MU9-M_u3 net23 A XU9-net6 VSS nch w=0.195u l=0.06u
MU4-M_u2 S net21 VSS VSS nch w=0.195u l=0.06u
MU3-M_u2 net7 B VSS VSS nch w=0.39u l=0.06u
MU2-M_u2 net9 net11 VSS VSS nch w=0.39u l=0.06u
MU1-M_u2 net11 A VSS VSS nch w=0.39u l=0.06u
MU5-M_u2 CO net23 VSS VSS nch w=0.195u l=0.06u
MU7-M_u3 net9 B net21 VSS nch w=0.29u l=0.06u
MU8-M_u3 net11 net7 net21 VSS nch w=0.205u l=0.06u
MU9-M_u2 net23 B VDD VDD pch w=0.26u l=0.06u
MU9-M_u1 net23 A VDD VDD pch w=0.26u l=0.06u
MU4-M_u3 S net21 VDD VDD pch w=0.26u l=0.06u
MU3-M_u3 net7 B VDD VDD pch w=0.285u l=0.06u
MU2-M_u3 net9 net11 VDD VDD pch w=0.52u l=0.06u
MU1-M_u3 net11 A VDD VDD pch w=0.52u l=0.06u
MU5-M_u3 CO net23 VDD VDD pch w=0.26u l=0.06u
MU7-M_u2 net9 net7 net21 VDD pch w=0.52u l=0.06u
MU8-M_u2 net11 B net21 VDD pch w=0.31u l=0.06u
.ends
.subckt HA1D1 A B S CO VDD VSS
MU9-M_u4 XU9-net6 B VSS VSS nch w=0.39u l=0.06u
MU9-M_u3 net23 A XU9-net6 VSS nch w=0.39u l=0.06u
MU4-M_u2 S net21 VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net7 B VSS VSS nch w=0.39u l=0.06u
MU2-M_u2 net9 net11 VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net11 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net11 A VSS VSS nch w=0.39u l=0.06u
MU5-M_u2 CO net23 VSS VSS nch w=0.39u l=0.06u
MU7-M_u3 net9 B net21 VSS nch w=0.29u l=0.06u
MU8-M_u3 net11 net7 net21 VSS nch w=0.205u l=0.06u
MU9-M_u2 net23 B VDD VDD pch w=0.52u l=0.06u
MU9-M_u1 net23 A VDD VDD pch w=0.52u l=0.06u
MU4-M_u3 S net21 VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net7 B VDD VDD pch w=0.285u l=0.06u
MU2-M_u3 net9 net11 VDD VDD pch w=0.52u l=0.06u
MU1_0-M_u3 net11 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net11 A VDD VDD pch w=0.52u l=0.06u
MU5-M_u3 CO net23 VDD VDD pch w=0.52u l=0.06u
MU7-M_u2 net9 net7 net21 VDD pch w=0.52u l=0.06u
MU8-M_u2 net11 B net21 VDD pch w=0.31u l=0.06u
.ends
.subckt HA1D2 A B S CO VDD VSS
MU9-M_u4 XU9-net6 B VSS VSS nch w=0.39u l=0.06u
MU9-M_u3 net23 A XU9-net6 VSS nch w=0.39u l=0.06u
MU4_0-M_u2 S net38 VSS VSS nch w=0.39u l=0.06u
MU4_1-M_u2 S net38 VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net36 B VSS VSS nch w=0.39u l=0.06u
MU2_0-M_u2 net43 net39 VSS VSS nch w=0.195u l=0.06u
MU2_1-M_u2 net43 net39 VSS VSS nch w=0.195u l=0.06u
MU1_0-M_u2 net39 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net39 A VSS VSS nch w=0.39u l=0.06u
MU5_0-M_u2 CO net23 VSS VSS nch w=0.39u l=0.06u
MU5_1-M_u2 CO net23 VSS VSS nch w=0.39u l=0.06u
MU7-M_u3 net43 B net38 VSS nch w=0.29u l=0.06u
MI1-M_u3 net39 net36 net38 VSS nch w=0.205u l=0.06u
MU9-M_u2 net23 B VDD VDD pch w=0.52u l=0.06u
MU9-M_u1 net23 A VDD VDD pch w=0.52u l=0.06u
MU4_0-M_u3 S net38 VDD VDD pch w=0.52u l=0.06u
MU4_1-M_u3 S net38 VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net36 B VDD VDD pch w=0.285u l=0.06u
MU2_0-M_u3 net43 net39 VDD VDD pch w=0.26u l=0.06u
MU2_1-M_u3 net43 net39 VDD VDD pch w=0.26u l=0.06u
MU1_0-M_u3 net39 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net39 A VDD VDD pch w=0.52u l=0.06u
MU5_0-M_u3 CO net23 VDD VDD pch w=0.52u l=0.06u
MU5_1-M_u3 CO net23 VDD VDD pch w=0.52u l=0.06u
MU7-M_u2 net43 net36 net38 VDD pch w=0.52u l=0.06u
MI1-M_u2 net39 B net38 VDD pch w=0.31u l=0.06u
.ends
.subckt HA1D4 A B S CO VDD VSS
MU9_0-M_u4 XU9_0-net6 B VSS VSS nch w=0.39u l=0.06u
MU9_0-M_u3 aaa A XU9_0-net6 VSS nch w=0.39u l=0.06u
MU9_1-M_u4 XU9_1-net6 B VSS VSS nch w=0.39u l=0.06u
MU9_1-M_u3 aaa A XU9_1-net6 VSS nch w=0.39u l=0.06u
MI3_0-M_u2 net40 net44 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 net40 net44 VSS VSS nch w=0.39u l=0.06u
MU4_0-M_u2 S net43 VSS VSS nch w=0.39u l=0.06u
MU4_1-M_u2 S net43 VSS VSS nch w=0.39u l=0.06u
MU4_2-M_u2 S net43 VSS VSS nch w=0.39u l=0.06u
MU4_3-M_u2 S net43 VSS VSS nch w=0.39u l=0.06u
MU3-M_u2 net29 B VSS VSS nch w=0.39u l=0.06u
MU1_0-M_u2 net44 A VSS VSS nch w=0.39u l=0.06u
MU1_1-M_u2 net44 A VSS VSS nch w=0.39u l=0.06u
MU1_2-M_u2 net44 A VSS VSS nch w=0.39u l=0.06u
MU5_0-M_u2 CO aaa VSS VSS nch w=0.39u l=0.06u
MU5_1-M_u2 CO aaa VSS VSS nch w=0.39u l=0.06u
MU5_2-M_u2 CO aaa VSS VSS nch w=0.39u l=0.06u
MU5_3-M_u2 CO aaa VSS VSS nch w=0.39u l=0.06u
MU7-M_u3 net40 B net43 VSS nch w=0.29u l=0.06u
MI1-M_u3 net44 net29 net43 VSS nch w=0.205u l=0.06u
MU9_0-M_u2 aaa B VDD VDD pch w=0.52u l=0.06u
MU9_0-M_u1 aaa A VDD VDD pch w=0.52u l=0.06u
MU9_1-M_u2 aaa B VDD VDD pch w=0.52u l=0.06u
MU9_1-M_u1 aaa A VDD VDD pch w=0.52u l=0.06u
MI3_0-M_u3 net40 net44 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 net40 net44 VDD VDD pch w=0.52u l=0.06u
MU4_0-M_u3 S net43 VDD VDD pch w=0.52u l=0.06u
MU4_1-M_u3 S net43 VDD VDD pch w=0.52u l=0.06u
MU4_2-M_u3 S net43 VDD VDD pch w=0.52u l=0.06u
MU4_3-M_u3 S net43 VDD VDD pch w=0.52u l=0.06u
MU3-M_u3 net29 B VDD VDD pch w=0.285u l=0.06u
MU1_0-M_u3 net44 A VDD VDD pch w=0.52u l=0.06u
MU1_1-M_u3 net44 A VDD VDD pch w=0.52u l=0.06u
MU1_2-M_u3 net44 A VDD VDD pch w=0.52u l=0.06u
MU5_0-M_u3 CO aaa VDD VDD pch w=0.52u l=0.06u
MU5_1-M_u3 CO aaa VDD VDD pch w=0.52u l=0.06u
MU5_2-M_u3 CO aaa VDD VDD pch w=0.52u l=0.06u
MU5_3-M_u3 CO aaa VDD VDD pch w=0.52u l=0.06u
MU7-M_u2 net40 net29 net43 VDD pch w=0.52u l=0.06u
MI1-M_u2 net44 B net43 VDD pch w=0.31u l=0.06u
.ends
.subckt HCOSCIND1 A CIN CS S CO VDD VSS
MI3-M_u4 XI3-net6 net17 VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 net6 A XI3-net6 VSS nch w=0.39u l=0.06u
MI25-M_u2 net74 net55 VSS VSS nch w=0.78u l=0.06u
MI5-M_u2 net34 CS VSS VSS nch w=0.195u l=0.06u
MI9-M_u2 S net69 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net72 A VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 CO net6 VSS VSS nch w=0.39u l=0.06u
MI0-M_u2 net17 CIN VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 net13 net17 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net55 A VSS VSS nch w=0.78u l=0.06u
MI12-M_u3 net15 CS net69 VSS nch w=0.29u l=0.06u
MI23-M_u3 net72 net34 net69 VSS nch w=0.29u l=0.06u
MI26-M_u3 net74 net17 net15 VSS nch w=0.15u l=0.06u
M_u6-M_u3 net55 net13 net15 VSS nch w=0.15u l=0.06u
MI3-M_u2 net6 net17 VDD VDD pch w=0.52u l=0.06u
MI3-M_u1 net6 A VDD VDD pch w=0.52u l=0.06u
MI25-M_u3 net74 net55 VDD VDD pch w=0.68u l=0.06u
MI5-M_u3 net34 CS VDD VDD pch w=0.26u l=0.06u
MI9-M_u3 S net69 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net72 A VDD VDD pch w=1.04u l=0.06u
MI13-M_u3 CO net6 VDD VDD pch w=0.52u l=0.06u
MI0-M_u3 net17 CIN VDD VDD pch w=0.26u l=0.06u
MI11-M_u3 net13 net17 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u3 net55 A VDD VDD pch w=1.04u l=0.06u
MI12-M_u2 net15 net34 net69 VDD pch w=0.34u l=0.06u
MI23-M_u2 net72 CS net69 VDD pch w=0.34u l=0.06u
MI26-M_u2 net74 net13 net15 VDD pch w=0.26u l=0.06u
M_u6-M_u2 net55 net17 net15 VDD pch w=0.15u l=0.06u
.ends
.subckt HCOSCIND2 A CIN CS S CO VDD VSS
MI3-M_u4 XI3-net6 net17 VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 net6 A XI3-net6 VSS nch w=0.39u l=0.06u
MI5-M_u2 net34 CS VSS VSS nch w=0.195u l=0.06u
MI9_0-M_u2 S net69 VSS VSS nch w=0.39u l=0.06u
MI9_1-M_u2 S net69 VSS VSS nch w=0.39u l=0.06u
MI24_0-M_u2 net72 A VSS VSS nch w=0.39u l=0.06u
MI24_1-M_u2 net72 A VSS VSS nch w=0.39u l=0.06u
MI13_0-M_u2 CO net6 VSS VSS nch w=0.39u l=0.06u
MI13_1-M_u2 CO net6 VSS VSS nch w=0.39u l=0.06u
MI0-M_u2 net17 CIN VSS VSS nch w=0.195u l=0.06u
MI22_0-M_u2 net74 net55 VSS VSS nch w=0.39u l=0.06u
MI22_1-M_u2 net74 net55 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 net13 net17 VSS VSS nch w=0.195u l=0.06u
M_u2_0-M_u2 net55 A VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 net55 A VSS VSS nch w=0.39u l=0.06u
MI25-M_u3 net74 net17 net15 VSS nch w=0.15u l=0.06u
MI12-M_u3 net15 CS net69 VSS nch w=0.29u l=0.06u
MI23-M_u3 net72 net34 net69 VSS nch w=0.29u l=0.06u
M_u6-M_u3 net55 net13 net15 VSS nch w=0.15u l=0.06u
MI3-M_u2 net6 net17 VDD VDD pch w=0.52u l=0.06u
MI3-M_u1 net6 A VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 net34 CS VDD VDD pch w=0.26u l=0.06u
MI9_0-M_u3 S net69 VDD VDD pch w=0.52u l=0.06u
MI9_1-M_u3 S net69 VDD VDD pch w=0.52u l=0.06u
MI24_0-M_u3 net72 A VDD VDD pch w=0.52u l=0.06u
MI24_1-M_u3 net72 A VDD VDD pch w=0.52u l=0.06u
MI13_0-M_u3 CO net6 VDD VDD pch w=0.52u l=0.06u
MI13_1-M_u3 CO net6 VDD VDD pch w=0.52u l=0.06u
MI0-M_u3 net17 CIN VDD VDD pch w=0.26u l=0.06u
MI22_0-M_u3 net74 net55 VDD VDD pch w=0.34u l=0.06u
MI22_1-M_u3 net74 net55 VDD VDD pch w=0.34u l=0.06u
MI11-M_u3 net13 net17 VDD VDD pch w=0.26u l=0.06u
M_u2_0-M_u3 net55 A VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 net55 A VDD VDD pch w=0.52u l=0.06u
MI25-M_u2 net74 net13 net15 VDD pch w=0.26u l=0.06u
MI12-M_u2 net15 net34 net69 VDD pch w=0.34u l=0.06u
MI23-M_u2 net72 CS net69 VDD pch w=0.34u l=0.06u
M_u6-M_u2 net55 net17 net15 VDD pch w=0.15u l=0.06u
.ends
.subckt HCOSCOND1 A CI CS S CON VDD VSS
MI11-M_u4 XI11-net6 CI VSS VSS nch w=0.39u l=0.06u
MI11-M_u3 CON A XI11-net6 VSS nch w=0.39u l=0.06u
MI24-M_u2 net51 A VSS VSS nch w=0.7u l=0.06u
MI22-M_u2 net66 net22 VSS VSS nch w=0.78u l=0.06u
MI13-M_u2 net22 A VSS VSS nch w=0.78u l=0.06u
MI1-M_u2 S net20 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net28 CI VSS VSS nch w=0.195u l=0.06u
MI5-M_u2 net32 CS VSS VSS nch w=0.195u l=0.06u
MI14-M_u3 net66 CI net8 VSS nch w=0.15u l=0.06u
MI23-M_u3 net51 net32 net20 VSS nch w=0.29u l=0.06u
M_u6-M_u3 net22 net28 net8 VSS nch w=0.15u l=0.06u
MI6-M_u3 net8 CS net20 VSS nch w=0.29u l=0.06u
MI11-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI11-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net51 A VDD VDD pch w=1.04u l=0.06u
MI22-M_u3 net66 net22 VDD VDD pch w=0.68u l=0.06u
MI13-M_u3 net22 A VDD VDD pch w=1.04u l=0.06u
MI1-M_u3 S net20 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net28 CI VDD VDD pch w=0.25u l=0.06u
MI5-M_u3 net32 CS VDD VDD pch w=0.26u l=0.06u
MI14-M_u2 net66 net28 net8 VDD pch w=0.26u l=0.06u
MI23-M_u2 net51 CS net20 VDD pch w=0.34u l=0.06u
M_u6-M_u2 net22 CI net8 VDD pch w=0.15u l=0.06u
MI6-M_u2 net8 net32 net20 VDD pch w=0.34u l=0.06u
.ends
.subckt HCOSCOND2 A CI CS S CON VDD VSS
MI11_0-M_u4 XI11_0-net6 CI VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u3 CON A XI11_0-net6 VSS nch w=0.39u l=0.06u
MI11_1-M_u4 XI11_1-net6 CI VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u3 CON A XI11_1-net6 VSS nch w=0.39u l=0.06u
MI24_0-M_u2 net51 A VSS VSS nch w=0.35u l=0.06u
MI24_1-M_u2 net51 A VSS VSS nch w=0.35u l=0.06u
MI22_0-M_u2 net66 net22 VSS VSS nch w=0.39u l=0.06u
MI22_1-M_u2 net66 net22 VSS VSS nch w=0.39u l=0.06u
MI13_0-M_u2 net22 A VSS VSS nch w=0.39u l=0.06u
MI13_1-M_u2 net22 A VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u2 S net40 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u2 S net40 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net28 CI VSS VSS nch w=0.195u l=0.06u
MI5-M_u2 net32 CS VSS VSS nch w=0.195u l=0.06u
MI14-M_u3 net66 CI net8 VSS nch w=0.15u l=0.06u
MI23-M_u3 net51 net32 net40 VSS nch w=0.29u l=0.06u
M_u6-M_u3 net22 net28 net8 VSS nch w=0.15u l=0.06u
MI6-M_u3 net8 CS net40 VSS nch w=0.29u l=0.06u
MI11_0-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI24_0-M_u3 net51 A VDD VDD pch w=0.52u l=0.06u
MI24_1-M_u3 net51 A VDD VDD pch w=0.52u l=0.06u
MI22_0-M_u3 net66 net22 VDD VDD pch w=0.34u l=0.06u
MI22_1-M_u3 net66 net22 VDD VDD pch w=0.34u l=0.06u
MI13_0-M_u3 net22 A VDD VDD pch w=0.52u l=0.06u
MI13_1-M_u3 net22 A VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u3 S net40 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u3 S net40 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net28 CI VDD VDD pch w=0.25u l=0.06u
MI5-M_u3 net32 CS VDD VDD pch w=0.26u l=0.06u
MI14-M_u2 net66 net28 net8 VDD pch w=0.26u l=0.06u
MI23-M_u2 net51 CS net40 VDD pch w=0.34u l=0.06u
M_u6-M_u2 net22 CI net8 VDD pch w=0.15u l=0.06u
MI6-M_u2 net8 net32 net40 VDD pch w=0.34u l=0.06u
.ends
.subckt HICIND1 A CIN S CO VDD VSS
M_u4-M_u2 net34 CIN VSS VSS nch w=0.39u l=0.06u
MI10-M_u2 net39 net11 VSS VSS nch w=0.78u l=0.06u
MI6-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI4-M_u2 net11 A VSS VSS nch w=0.78u l=0.06u
MI7-M_u2 CO net40 VSS VSS nch w=0.39u l=0.06u
MI2-M_u4 XI2-net6 net34 VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 net40 A XI2-net6 VSS nch w=0.39u l=0.06u
MI9-M_u3 net39 net34 net28 VSS nch w=0.29u l=0.06u
MI3-M_u3 net11 CIN net28 VSS nch w=0.29u l=0.06u
M_u4-M_u3 net34 CIN VDD VDD pch w=0.52u l=0.06u
MI10-M_u3 net39 net11 VDD VDD pch w=1.04u l=0.06u
MI6-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI4-M_u3 net11 A VDD VDD pch w=1.04u l=0.06u
MI7-M_u3 CO net40 VDD VDD pch w=0.52u l=0.06u
MI2-M_u2 net40 net34 VDD VDD pch w=0.52u l=0.06u
MI2-M_u1 net40 A VDD VDD pch w=0.52u l=0.06u
MI9-M_u2 net39 CIN net28 VDD pch w=0.52u l=0.06u
MI3-M_u2 net11 net34 net28 VDD pch w=0.32u l=0.06u
.ends
.subckt HICIND2 A CIN S CO VDD VSS
M_u4-M_u2 net34 CIN VSS VSS nch w=0.39u l=0.06u
MI10_0-M_u2 net39 net11 VSS VSS nch w=0.39u l=0.06u
MI10_1-M_u2 net39 net11 VSS VSS nch w=0.39u l=0.06u
MI11_0-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI11_1-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI4_0-M_u2 net11 A VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 net11 A VSS VSS nch w=0.39u l=0.06u
MI7_0-M_u2 CO net40 VSS VSS nch w=0.39u l=0.06u
MI7_1-M_u2 CO net40 VSS VSS nch w=0.39u l=0.06u
MI2-M_u4 XI2-net6 net34 VSS VSS nch w=0.39u l=0.06u
MI2-M_u3 net40 A XI2-net6 VSS nch w=0.39u l=0.06u
MI9-M_u3 net39 net34 net28 VSS nch w=0.29u l=0.06u
MI3-M_u3 net11 CIN net28 VSS nch w=0.29u l=0.06u
M_u4-M_u3 net34 CIN VDD VDD pch w=0.52u l=0.06u
MI10_0-M_u3 net39 net11 VDD VDD pch w=0.52u l=0.06u
MI10_1-M_u3 net39 net11 VDD VDD pch w=0.52u l=0.06u
MI11_0-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI11_1-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI4_0-M_u3 net11 A VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 net11 A VDD VDD pch w=0.52u l=0.06u
MI7_0-M_u3 CO net40 VDD VDD pch w=0.52u l=0.06u
MI7_1-M_u3 CO net40 VDD VDD pch w=0.52u l=0.06u
MI2-M_u2 net40 net34 VDD VDD pch w=0.52u l=0.06u
MI2-M_u1 net40 A VDD VDD pch w=0.52u l=0.06u
MI9-M_u2 net39 CIN net28 VDD pch w=0.52u l=0.06u
MI3-M_u2 net11 net34 net28 VDD pch w=0.32u l=0.06u
.ends
.subckt HICOND1 A CI S CON VDD VSS
MI5-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI3-M_u2 net35 CI VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net32 net18 VSS VSS nch w=0.78u l=0.06u
MI4-M_u2 net18 A VSS VSS nch w=0.78u l=0.06u
MI7-M_u4 XI7-net6 CI VSS VSS nch w=0.39u l=0.06u
MI7-M_u3 CON A XI7-net6 VSS nch w=0.39u l=0.06u
MI6-M_u3 net18 net35 net28 VSS nch w=0.205u l=0.06u
M_u7-M_u3 net32 CI net28 VSS nch w=0.29u l=0.06u
MI5-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI3-M_u3 net35 CI VDD VDD pch w=0.285u l=0.06u
MI2-M_u3 net32 net18 VDD VDD pch w=1.04u l=0.06u
MI4-M_u3 net18 A VDD VDD pch w=1.04u l=0.06u
MI7-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI7-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI6-M_u2 net18 CI net28 VDD pch w=0.31u l=0.06u
M_u7-M_u2 net32 net35 net28 VDD pch w=0.52u l=0.06u
.ends
.subckt HICOND2 A CI S CON VDD VSS
MI5_0-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI5_1-M_u2 S net28 VSS VSS nch w=0.39u l=0.06u
MI3-M_u2 net35 CI VSS VSS nch w=0.39u l=0.06u
MI2_0-M_u2 net32 net18 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u2 net32 net18 VSS VSS nch w=0.39u l=0.06u
MI4_0-M_u2 net18 A VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 net18 A VSS VSS nch w=0.39u l=0.06u
MI7_0-M_u4 XI7_0-net6 CI VSS VSS nch w=0.39u l=0.06u
MI7_0-M_u3 CON A XI7_0-net6 VSS nch w=0.39u l=0.06u
MI7_1-M_u4 XI7_1-net6 CI VSS VSS nch w=0.39u l=0.06u
MI7_1-M_u3 CON A XI7_1-net6 VSS nch w=0.39u l=0.06u
MI6-M_u3 net18 net35 net28 VSS nch w=0.205u l=0.06u
M_u7-M_u3 net32 CI net28 VSS nch w=0.29u l=0.06u
MI5_0-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI5_1-M_u3 S net28 VDD VDD pch w=0.52u l=0.06u
MI3-M_u3 net35 CI VDD VDD pch w=0.285u l=0.06u
MI2_0-M_u3 net32 net18 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u3 net32 net18 VDD VDD pch w=0.52u l=0.06u
MI4_0-M_u3 net18 A VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 net18 A VDD VDD pch w=0.52u l=0.06u
MI7_0-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI7_0-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI7_1-M_u2 CON CI VDD VDD pch w=0.52u l=0.06u
MI7_1-M_u1 CON A VDD VDD pch w=0.52u l=0.06u
MI6-M_u2 net18 CI net28 VDD pch w=0.31u l=0.06u
M_u7-M_u2 net32 net35 net28 VDD pch w=0.52u l=0.06u
.ends
.subckt IAO21D0 A1 A2 B ZN VDD VSS
MI1-M_u4 net11 A1 VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 net11 A2 VSS VSS nch w=0.195u l=0.06u
MU39-M_u4 ZN B VSS VSS nch w=0.195u l=0.06u
MU39-M_u3 ZN net11 VSS VSS nch w=0.195u l=0.06u
MI1-M_u1 XI1-net8 A2 VDD VDD pch w=0.26u l=0.06u
MI1-M_u2 net11 A1 XI1-net8 VDD pch w=0.26u l=0.06u
MU39-M_u1 XU39-net8 net11 VDD VDD pch w=0.26u l=0.06u
MU39-M_u2 ZN B XU39-net8 VDD pch w=0.26u l=0.06u
.ends
.subckt IAO21D1 A1 A2 B ZN VDD VSS
MU37-M_u4 net11 A1 VSS VSS nch w=0.195u l=0.06u
MU37-M_u3 net11 A2 VSS VSS nch w=0.195u l=0.06u
MU39-M_u4 ZN B VSS VSS nch w=0.39u l=0.06u
MU39-M_u3 ZN net11 VSS VSS nch w=0.39u l=0.06u
MU37-M_u1 XU37-net8 A2 VDD VDD pch w=0.26u l=0.06u
MU37-M_u2 net11 A1 XU37-net8 VDD pch w=0.26u l=0.06u
MU39-M_u1 XU39-net8 net11 VDD VDD pch w=0.52u l=0.06u
MU39-M_u2 ZN B XU39-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt IAO21D2 A1 A2 B ZN VDD VSS
MU37-M_u4 net11 A1 VSS VSS nch w=0.39u l=0.06u
MU37-M_u3 net11 A2 VSS VSS nch w=0.39u l=0.06u
MU39_0-M_u4 ZN B VSS VSS nch w=0.39u l=0.06u
MU39_0-M_u3 ZN net11 VSS VSS nch w=0.39u l=0.06u
MU39_1-M_u4 ZN B VSS VSS nch w=0.39u l=0.06u
MU39_1-M_u3 ZN net11 VSS VSS nch w=0.39u l=0.06u
MU37-M_u1 XU37-net8 A2 VDD VDD pch w=0.52u l=0.06u
MU37-M_u2 net11 A1 XU37-net8 VDD pch w=0.52u l=0.06u
MU39_0-M_u1 XU39_0-net8 net11 VDD VDD pch w=0.52u l=0.06u
MU39_0-M_u2 ZN B XU39_0-net8 VDD pch w=0.52u l=0.06u
MU39_1-M_u1 XU39_1-net8 net11 VDD VDD pch w=0.52u l=0.06u
MU39_1-M_u2 ZN B XU39_1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt IAO21D4 A1 A2 B ZN VDD VSS
MU37-M_u4 p0 A1 VSS VSS nch w=0.39u l=0.06u
MU37-M_u3 p0 A2 VSS VSS nch w=0.39u l=0.06u
MU39-M_u4 ZN B VSS VSS nch w=1.56u l=0.06u
MU39-M_u3 ZN p0 VSS VSS nch w=1.56u l=0.06u
MU37-M_u1 XU37-net8 A2 VDD VDD pch w=0.52u l=0.06u
MU37-M_u2 p0 A1 XU37-net8 VDD pch w=0.52u l=0.06u
MU39-M_u1 XU39-net8 p0 VDD VDD pch w=2.08u l=0.06u
MU39-M_u2 ZN B XU39-net8 VDD pch w=2.08u l=0.06u
.ends
.subckt IAO22D0 A1 A2 B1 B2 ZN VDD VSS
MU37-M_u4 net42 A1 VSS VSS nch w=0.195u l=0.06u
MU37-M_u3 net42 A2 VSS VSS nch w=0.195u l=0.06u
MI5 ZN net42 VSS VSS nch w=0.195u l=0.06u
MI6 net34 B2 VSS VSS nch w=0.195u l=0.06u
MI2 ZN B1 net34 VSS nch w=0.195u l=0.06u
MU37-M_u1 XU37-net8 A2 VDD VDD pch w=0.26u l=0.06u
MU37-M_u2 net42 A1 XU37-net8 VDD pch w=0.26u l=0.06u
MI4 net32 net42 ZN VDD pch w=0.26u l=0.06u
MI1 VDD B1 net32 VDD pch w=0.26u l=0.06u
M_u3 VDD B2 net32 VDD pch w=0.26u l=0.06u
.ends
.subckt IAO22D1 A1 A2 B1 B2 ZN VDD VSS
MU37-M_u4 net42 A1 VSS VSS nch w=0.195u l=0.06u
MU37-M_u3 net42 A2 VSS VSS nch w=0.195u l=0.06u
MI2 ZN B1 net34 VSS nch w=0.39u l=0.06u
MI3 net34 B2 VSS VSS nch w=0.39u l=0.06u
M_u7 ZN net42 VSS VSS nch w=0.39u l=0.06u
MU37-M_u1 XU37-net8 A2 VDD VDD pch w=0.26u l=0.06u
MU37-M_u2 net42 A1 XU37-net8 VDD pch w=0.26u l=0.06u
M_u4 net32 net42 ZN VDD pch w=0.52u l=0.06u
M_u2 net32 B1 VDD VDD pch w=0.52u l=0.06u
M_u3 VDD B2 net32 VDD pch w=0.52u l=0.06u
.ends
.subckt IAO22D2 A1 A2 B1 B2 ZN VDD VSS
MU52 net32 net6 net23 VSS nch w=0.39u l=0.06u
MU54 net23 A1 VSS VSS nch w=0.39u l=0.06u
MU53 net23 A2 VSS VSS nch w=0.39u l=0.06u
MU50-M_u4 XU50-net6 B1 VSS VSS nch w=0.39u l=0.06u
MU50-M_u3 net6 B2 XU50-net6 VSS nch w=0.39u l=0.06u
MU51_0-M_u2 ZN net32 VSS VSS nch w=0.39u l=0.06u
MU51_1-M_u2 ZN net32 VSS VSS nch w=0.39u l=0.06u
MU50-M_u2 net6 B1 VDD VDD pch w=0.26u l=0.06u
MU50-M_u1 net6 B2 VDD VDD pch w=0.26u l=0.06u
MI16-MI12 net32 A2 XI16-net11 VDD pch w=0.52u l=0.06u
MI16-MI13 XI16-net11 A1 VDD VDD pch w=0.52u l=0.06u
MU47 net32 net6 VDD VDD pch w=0.52u l=0.06u
MU51_0-M_u1 ZN net32 VDD VDD pch w=0.52u l=0.06u
MU51_1-M_u1 ZN net32 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IAO22D4 A1 A2 B1 B2 ZN VDD VSS
MU52 p0 net24 net28 VSS nch w=0.78u l=0.06u
MI5 net28 A1 VSS VSS nch w=0.78u l=0.06u
MI4 net28 A2 VSS VSS nch w=0.78u l=0.06u
MU50-M_u4 XU50-net6 B1 VSS VSS nch w=0.39u l=0.06u
MU50-M_u3 net24 B2 XU50-net6 VSS nch w=0.39u l=0.06u
MU51_0-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU51_1-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU51_2-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU51_3-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU50-M_u2 net24 B1 VDD VDD pch w=0.26u l=0.06u
MU50-M_u1 net24 B2 VDD VDD pch w=0.26u l=0.06u
MI16-MI12 p0 A2 XI16-net11 VDD pch w=1.04u l=0.06u
MI16-MI13 XI16-net11 A1 VDD VDD pch w=1.04u l=0.06u
MU47_0 p0 net24 VDD VDD pch w=0.52u l=0.06u
MU47_1 p0 net24 VDD VDD pch w=0.52u l=0.06u
MU51_0-M_u1 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU51_1-M_u1 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU51_2-M_u1 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU51_3-M_u1 ZN p0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IIND4D0 A1 A2 B1 B2 ZN VDD VSS
MI21-M_u5 ZN net25 XI21-net23 VSS nch w=0.195u l=0.06u
MI21-MI0 XI21-net23 B1 XI21-net26 VSS nch w=0.195u l=0.06u
MI21-MI1 XI21-net26 B2 XI21-net29 VSS nch w=0.195u l=0.06u
MI21-MI2 XI21-net29 net23 VSS VSS nch w=0.195u l=0.06u
MI19-M_u2 net25 A1 VSS VSS nch w=0.195u l=0.06u
MI20-M_u2 net23 A2 VSS VSS nch w=0.195u l=0.06u
MI21-M_u4 ZN net23 VDD VDD pch w=0.26u l=0.06u
MI21-M_u3 ZN B2 VDD VDD pch w=0.26u l=0.06u
MI21-M_u2 ZN B1 VDD VDD pch w=0.26u l=0.06u
MI21-M_u1 ZN net25 VDD VDD pch w=0.26u l=0.06u
MI19-M_u3 net25 A1 VDD VDD pch w=0.26u l=0.06u
MI20-M_u3 net23 A2 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt IIND4D1 A1 A2 B1 B2 ZN VDD VSS
MI21-M_u5 ZN net25 XI21-net23 VSS nch w=0.39u l=0.06u
MI21-MI0 XI21-net23 B1 XI21-net26 VSS nch w=0.39u l=0.06u
MI21-MI1 XI21-net26 B2 XI21-net29 VSS nch w=0.39u l=0.06u
MI21-MI2 XI21-net29 net23 VSS VSS nch w=0.39u l=0.06u
MI19-M_u2 net25 A1 VSS VSS nch w=0.195u l=0.06u
MI20-M_u2 net23 A2 VSS VSS nch w=0.195u l=0.06u
MI21-M_u4 ZN net23 VDD VDD pch w=0.52u l=0.06u
MI21-M_u3 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI21-M_u2 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI21-M_u1 ZN net25 VDD VDD pch w=0.52u l=0.06u
MI19-M_u3 net25 A1 VDD VDD pch w=0.26u l=0.06u
MI20-M_u3 net23 A2 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt IIND4D2 A1 A2 B1 B2 ZN VDD VSS
MI47-M_u2 net97 A2 VSS VSS nch w=0.39u l=0.06u
MI24-M_u2 net48 A1 VSS VSS nch w=0.39u l=0.06u
MI42 p2 net97 VSS VSS nch w=0.39u l=0.06u
MI44 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI40 net75 B1 p1 VSS nch w=0.39u l=0.06u
MI46 ZN net48 net75 VSS nch w=0.39u l=0.06u
MI41 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI43 p2 net97 VSS VSS nch w=0.39u l=0.06u
MI35 ZN net48 net75 VSS nch w=0.39u l=0.06u
MI45 net75 B1 p1 VSS nch w=0.39u l=0.06u
MI47-M_u3 net97 A2 VDD VDD pch w=0.52u l=0.06u
MI24-M_u3 net48 A1 VDD VDD pch w=0.52u l=0.06u
MI38_0 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI38_1 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI2_0 ZN net97 VDD VDD pch w=0.52u l=0.06u
MI2_1 ZN net97 VDD VDD pch w=0.52u l=0.06u
MI37_0 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI37_1 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI39_0 ZN net48 VDD VDD pch w=0.52u l=0.06u
MI39_1 ZN net48 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IIND4D4 A1 A2 B1 B2 ZN VDD VSS
MI29_0-M_u2 p3 A2 VSS VSS nch w=0.39u l=0.06u
MI29_1-M_u2 p3 A2 VSS VSS nch w=0.39u l=0.06u
MI22_0-M_u2 p4 A1 VSS VSS nch w=0.39u l=0.06u
MI22_1-M_u2 p4 A1 VSS VSS nch w=0.39u l=0.06u
MI35_0 p2 p3 VSS VSS nch w=0.39u l=0.06u
MI35_1 p2 p3 VSS VSS nch w=0.39u l=0.06u
MI35_2 p2 p3 VSS VSS nch w=0.39u l=0.06u
MI35_3 p2 p3 VSS VSS nch w=0.39u l=0.06u
MI33_0 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI33_1 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI33_2 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI33_3 p0 B1 p1 VSS nch w=0.39u l=0.06u
MI34_0 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI34_1 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI34_2 p1 B2 p2 VSS nch w=0.39u l=0.06u
MI34_3 p1 B2 p2 VSS nch w=0.39u l=0.06u
MU53_0 ZN p4 p0 VSS nch w=0.39u l=0.06u
MU53_1 ZN p4 p0 VSS nch w=0.39u l=0.06u
MU53_2 ZN p4 p0 VSS nch w=0.39u l=0.06u
MU53_3 ZN p4 p0 VSS nch w=0.39u l=0.06u
MI29_0-M_u3 p3 A2 VDD VDD pch w=0.52u l=0.06u
MI29_1-M_u3 p3 A2 VDD VDD pch w=0.52u l=0.06u
MI22_0-M_u3 p4 A1 VDD VDD pch w=0.52u l=0.06u
MI22_1-M_u3 p4 A1 VDD VDD pch w=0.52u l=0.06u
MI32_0 ZN p4 VDD VDD pch w=0.52u l=0.06u
MI32_1 ZN p4 VDD VDD pch w=0.52u l=0.06u
MI32_2 ZN p4 VDD VDD pch w=0.52u l=0.06u
MI32_3 ZN p4 VDD VDD pch w=0.52u l=0.06u
MI2_0 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI2_1 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI2_2 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI2_3 ZN p3 VDD VDD pch w=0.52u l=0.06u
MI30_0 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI30_1 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI30_2 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI30_3 ZN B2 VDD VDD pch w=0.52u l=0.06u
MI31_0 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI31_1 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI31_2 ZN B1 VDD VDD pch w=0.52u l=0.06u
MI31_3 ZN B1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt IINR4D0 A1 A2 B1 B2 ZN VDD VSS
MI27 ZN B1 VSS VSS nch w=0.195u l=0.06u
MI16 ZN net42 VSS VSS nch w=0.195u l=0.06u
MI28 ZN B2 VSS VSS nch w=0.195u l=0.06u
MI26 ZN net33 VSS VSS nch w=0.195u l=0.06u
MI29-M_u2 net33 A2 VSS VSS nch w=0.195u l=0.06u
MI11-M_u2 net42 A1 VSS VSS nch w=0.195u l=0.06u
MI29-M_u3 net33 A2 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 net42 A1 VDD VDD pch w=0.27u l=0.06u
MI22 p0 B2 VDD VDD pch w=0.52u l=0.06u
MI24 p2 net33 p1 VDD pch w=0.52u l=0.06u
MI23 p1 B1 p0 VDD pch w=0.52u l=0.06u
MI25 ZN net42 p2 VDD pch w=0.52u l=0.06u
.ends
.subckt IINR4D1 A1 A2 B1 B2 ZN VDD VSS
MI25 ZN B2 VSS VSS nch w=0.21u l=0.06u
MI16 ZN net43 VSS VSS nch w=0.21u l=0.06u
MI23 ZN net41 VSS VSS nch w=0.21u l=0.06u
MI24 ZN B1 VSS VSS nch w=0.21u l=0.06u
MI36-M_u2 net43 A1 VSS VSS nch w=0.205u l=0.06u
MI37-M_u2 net41 A2 VSS VSS nch w=0.205u l=0.06u
MI36-M_u3 net43 A1 VDD VDD pch w=0.27u l=0.06u
MI37-M_u3 net41 A2 VDD VDD pch w=0.27u l=0.06u
MI22 net68 B2 VDD VDD pch w=0.52u l=0.06u
MI32 net55 B2 VDD VDD pch w=0.52u l=0.06u
MI27 net58 net41 net49 VDD pch w=0.52u l=0.06u
MI26 net49 B1 net68 VDD pch w=0.52u l=0.06u
MI31 net54 B1 net55 VDD pch w=0.52u l=0.06u
MI28 ZN net43 net58 VDD pch w=0.52u l=0.06u
MI29 ZN net43 net48 VDD pch w=0.52u l=0.06u
MI30 net48 net41 net54 VDD pch w=0.52u l=0.06u
.ends
.subckt IINR4D2 A1 A2 B1 B2 ZN VDD VSS
MI38_0 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI38_1 ZN B2 VSS VSS nch w=0.39u l=0.06u
MI37_0 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI37_1 ZN B1 VSS VSS nch w=0.39u l=0.06u
MI16_0 ZN net39 VSS VSS nch w=0.39u l=0.06u
MI16_1 ZN net39 VSS VSS nch w=0.39u l=0.06u
MI36_0 ZN net22 VSS VSS nch w=0.39u l=0.06u
MI36_1 ZN net22 VSS VSS nch w=0.39u l=0.06u
MI51-M_u2 net39 A1 VSS VSS nch w=0.39u l=0.06u
MI50-M_u2 net22 A2 VSS VSS nch w=0.39u l=0.06u
MI51-M_u3 net39 A1 VDD VDD pch w=0.52u l=0.06u
MI50-M_u3 net22 A2 VDD VDD pch w=0.52u l=0.06u
MI39 net55 B2 VDD VDD pch w=0.52u l=0.06u
MI40 net59 B1 net55 VDD pch w=0.52u l=0.06u
MI41 ZN net39 net58 VDD pch w=0.52u l=0.06u
MI42 net58 net22 net59 VDD pch w=0.52u l=0.06u
MI22 net55 B2 VDD VDD pch w=0.52u l=0.06u
MI32 net55 B2 VDD VDD pch w=0.52u l=0.06u
MI45 net58 net22 net59 VDD pch w=0.52u l=0.06u
MI46 ZN net39 net58 VDD pch w=0.52u l=0.06u
MI47 net59 B1 net55 VDD pch w=0.52u l=0.06u
MI48 net55 B2 VDD VDD pch w=0.52u l=0.06u
MI27 net58 net22 net59 VDD pch w=0.52u l=0.06u
MI26 net59 B1 net55 VDD pch w=0.52u l=0.06u
MI31 net59 B1 net55 VDD pch w=0.52u l=0.06u
MI28 ZN net39 net58 VDD pch w=0.52u l=0.06u
MI29 ZN net39 net58 VDD pch w=0.52u l=0.06u
MI30 net58 net22 net59 VDD pch w=0.52u l=0.06u
.ends
.subckt IINR4D4 A1 A2 B1 B2 ZN VDD VSS
MI67_0 ZN B2 VSS VSS nch w=0.3u l=0.06u
MI67_1 ZN B2 VSS VSS nch w=0.3u l=0.06u
MI66_0 ZN B1 VSS VSS nch w=0.3u l=0.06u
MI66_1 ZN B1 VSS VSS nch w=0.3u l=0.06u
MI65_0 ZN p0 VSS VSS nch w=0.3u l=0.06u
MI65_1 ZN p0 VSS VSS nch w=0.3u l=0.06u
MI61_0 ZN p1 VSS VSS nch w=0.3u l=0.06u
MI61_1 ZN p1 VSS VSS nch w=0.3u l=0.06u
MI55_0-M_u2 p0 A2 VSS VSS nch w=0.39u l=0.06u
MI55_1-M_u2 p0 A2 VSS VSS nch w=0.39u l=0.06u
MI48_0-M_u2 p1 A1 VSS VSS nch w=0.39u l=0.06u
MI48_1-M_u2 p1 A1 VSS VSS nch w=0.39u l=0.06u
MI55_0-M_u3 p0 A2 VDD VDD pch w=0.52u l=0.06u
MI55_1-M_u3 p0 A2 VDD VDD pch w=0.52u l=0.06u
MI48_0-M_u3 p1 A1 VDD VDD pch w=0.52u l=0.06u
MI48_1-M_u3 p1 A1 VDD VDD pch w=0.52u l=0.06u
MI62 net045 B1 net048 VDD pch w=4.32u l=0.06u
MI63 net042 p0 net045 VDD pch w=4.32u l=0.06u
MI64 ZN p1 net042 VDD pch w=4.32u l=0.06u
MI22 net048 B2 VDD VDD pch w=4.32u l=0.06u
.ends
.subckt IND2D0 A1 B1 ZN VDD VSS
MI2-M_u2 net13 A1 VSS VSS nch w=0.195u l=0.06u
MI13 net16 net13 VSS VSS nch w=0.195u l=0.06u
MI12 ZN B1 net16 VSS nch w=0.195u l=0.06u
MI2-M_u3 net13 A1 VDD VDD pch w=0.25u l=0.06u
M_u16 VDD net13 ZN VDD pch w=0.25u l=0.06u
MI11 VDD B1 ZN VDD pch w=0.25u l=0.06u
.ends
.subckt IND2D1 A1 B1 ZN VDD VSS
MI2-M_u2 net13 A1 VSS VSS nch w=0.195u l=0.06u
MI13 net16 net13 VSS VSS nch w=0.39u l=0.06u
MI12 ZN B1 net16 VSS nch w=0.39u l=0.06u
MI2-M_u3 net13 A1 VDD VDD pch w=0.26u l=0.06u
M_u16 VDD net13 ZN VDD pch w=0.52u l=0.06u
MI11 VDD B1 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt IND2D2 A1 B1 ZN VDD VSS
MI9-M_u2 net18 A1 VSS VSS nch w=0.39u l=0.06u
MI10 ZN net18 net20 VSS nch w=0.39u l=0.06u
MI11 net20 B1 VSS VSS nch w=0.39u l=0.06u
MI4 net22 B1 VSS VSS nch w=0.39u l=0.06u
MI12 ZN net18 net22 VSS nch w=0.39u l=0.06u
MI9-M_u3 net18 A1 VDD VDD pch w=0.52u l=0.06u
M_u16 VDD B1 ZN VDD pch w=1.04u l=0.06u
MI3 VDD net18 ZN VDD pch w=1.04u l=0.06u
.ends
.subckt IND2D4 A1 B1 ZN VDD VSS
MI2_0-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI2_1-M_u2 p0 A1 VSS VSS nch w=0.39u l=0.06u
MI13 net017 p0 VSS VSS nch w=1.56u l=0.06u
MI12 ZN B1 net017 VSS nch w=1.56u l=0.06u
MI2_0-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
MI2_1-M_u3 p0 A1 VDD VDD pch w=0.52u l=0.06u
M_u16_0 VDD p0 ZN VDD pch w=0.52u l=0.06u
M_u16_1 VDD p0 ZN VDD pch w=0.52u l=0.06u
M_u16_2 VDD p0 ZN VDD pch w=0.52u l=0.06u
M_u16_3 VDD p0 ZN VDD pch w=0.52u l=0.06u
MI11_0 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI11_1 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI11_2 VDD B1 ZN VDD pch w=0.52u l=0.06u
MI11_3 VDD B1 ZN VDD pch w=0.52u l=0.06u
.ends
.subckt IND3D0 A1 B1 B2 ZN VDD VSS
MI5-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12 ZN B2 net23 VSS nch w=0.195u l=0.06u
MI16 net20 net30 VSS VSS nch w=0.195u l=0.06u
MI15 net23 B1 net20 VSS nch w=0.195u l=0.06u
MI5-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI9 VDD B2 ZN VDD pch w=0.26u l=0.06u
MI13 VDD B1 ZN VDD pch w=0.26u l=0.06u
MI14 VDD net30 ZN VDD pch w=0.26u l=0.06u
.ends
.subckt IND3D1 A1 B1 B2 ZN VDD VSS
MI5-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12 ZN B2 net23 VSS nch w=0.39u l=0.06u
MI7 net20 net30 VSS VSS nch w=0.39u l=0.06u
MI6 net23 B1 net20 VSS nch w=0.39u l=0.06u
MI5-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI11 VDD B2 ZN VDD pch w=0.52u l=0.06u
M_u16 VDD B1 ZN VDD pch w=0.52u l=0.06u
