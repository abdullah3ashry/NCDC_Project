MI96_1-M_u3 d3 d2 VDD VDD pch w=0.52u l=0.06u
MI112-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI45 d0 INCPB net126 VDD pch w=0.15u l=0.06u
MI43 net126 d1 VDD VDD pch w=0.15u l=0.06u
MI71 net104 net120 net131 VDD pch w=0.2u l=0.06u
MI73 net75 D VDD VDD pch w=0.52u l=0.06u
MI74 d0 INCP net104 VDD pch w=0.29u l=0.06u
MI75 net131 SI VDD VDD pch w=0.2u l=0.06u
MI101 net104 SE net75 VDD pch w=0.44u l=0.06u
MI97 net087 INCP d2 VDD pch w=0.15u l=0.06u
MI98 d1 INCPB d2 VDD pch w=0.31u l=0.06u
MI93-M_u2 net087 d3 VDD VDD pch w=0.2u l=0.06u
MI93-M_u1 net087 SDN VDD VDD pch w=0.2u l=0.06u
MI16-M_u2 d1 d0 VDD VDD pch w=0.52u l=0.06u
MI16-M_u1 d1 SDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SDFXD0 DA DB SA SI SE CP Q QN VDD VSS
MI24 net76 net72 VDD VDD pch w=0.15u l=0.06u
MI38 net138 INCP net76 VDD pch w=0.15u l=0.06u
MI153 d0 INCP net88 VDD pch w=0.3u l=0.06u
MI222 net111 net169 VDD VDD pch w=0.27u l=0.06u
MI150 net88 DA net94 VDD pch w=0.35u l=0.06u
MI233 net88 SA net91 VDD pch w=0.2u l=0.06u
MI151 net94 net128 net93 VDD pch w=0.35u l=0.06u
MI232 net91 DB net93 VDD pch w=0.2u l=0.06u
MI234 net88 net118 net90 VDD pch w=0.15u l=0.06u
MI231 net93 SE VDD VDD pch w=0.35u l=0.06u
MI235 net90 SI VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net117 VDD pch w=0.15u l=0.06u
MI102 net117 net169 VDD VDD pch w=0.15u l=0.06u
MI223 net138 INCPB net111 VDD pch w=0.27u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI229-M_u3 net128 SA VDD VDD pch w=0.2u l=0.06u
MI218-M_u3 QN net72 VDD VDD pch w=0.26u l=0.06u
MI214-M_u3 net72 net138 VDD VDD pch w=0.2u l=0.06u
MI123-M_u3 net169 d0 VDD VDD pch w=0.26u l=0.06u
MI228-M_u3 Q net138 VDD VDD pch w=0.26u l=0.06u
MI230-M_u3 net118 SE VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI41 net73 net72 VSS VSS nch w=0.15u l=0.06u
MI29 net138 INCPB net73 VSS nch w=0.15u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI229-M_u2 net128 SA VSS VSS nch w=0.15u l=0.06u
MI218-M_u2 QN net72 VSS VSS nch w=0.195u l=0.06u
MI214-M_u2 net72 net138 VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 net169 d0 VSS VSS nch w=0.195u l=0.06u
MI228-M_u2 Q net138 VSS VSS nch w=0.195u l=0.06u
MI230-M_u2 net118 SE VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI119 net158 net169 VSS VSS nch w=0.15u l=0.06u
MI240 net155 net118 VSS VSS nch w=0.355u l=0.06u
MI236 net152 SI VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net158 VSS nch w=0.15u l=0.06u
MI239 net146 DB net155 VSS nch w=0.175u l=0.06u
MI237 net153 SE net152 VSS nch w=0.15u l=0.06u
MI163 net143 SA net155 VSS nch w=0.175u l=0.06u
MI238 net153 net128 net146 VSS nch w=0.175u l=0.06u
MI160 net153 DA net143 VSS nch w=0.175u l=0.06u
MI225 net141 net169 VSS VSS nch w=0.205u l=0.06u
MI227 net138 INCP net141 VSS nch w=0.22u l=0.06u
MI164 d0 INCPB net153 VSS nch w=0.195u l=0.06u
.ends
.subckt SDFXD1 DA DB SA SI SE CP Q QN VDD VSS
MI218-M_u3 QN net098 VDD VDD pch w=0.52u l=0.06u
MI241-M_u3 net0124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0122 SA VDD VDD pch w=0.26u l=0.06u
MI228-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI214-M_u3 net098 net82 VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 net086 d0 VDD VDD pch w=0.26u l=0.06u
MI231 net0147 SE VDD VDD pch w=0.35u l=0.06u
MI233 net208 SA net0145 VDD pch w=0.435u l=0.06u
MI232 net0145 DB net0147 VDD pch w=0.255u l=0.06u
MI102 net144 net086 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net144 VDD pch w=0.15u l=0.06u
MI223 net82 INCPB net0171 VDD pch w=0.27u l=0.06u
MI234 net208 net0124 net0148 VDD pch w=0.2u l=0.06u
MI235 net0148 SI VDD VDD pch w=0.2u l=0.06u
MI222 net0171 net086 VDD VDD pch w=0.27u l=0.06u
MI150 net208 DA net162 VDD pch w=0.35u l=0.06u
MI151 net162 net0122 net0147 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net208 VDD pch w=0.3u l=0.06u
MI38 net82 INCP net070 VDD pch w=0.15u l=0.06u
MI24 net070 net098 VDD VDD pch w=0.15u l=0.06u
MI237 net265 SE net099 VSS nch w=0.15u l=0.06u
MI238 net265 net0122 net096 VSS nch w=0.175u l=0.06u
MI239 net096 DB net093 VSS nch w=0.175u l=0.06u
MI227 net82 INCP net0118 VSS nch w=0.22u l=0.06u
MI240 net093 net0124 VSS VSS nch w=0.355u l=0.06u
MI119 net79 net086 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net79 VSS nch w=0.15u l=0.06u
MI225 net0118 net086 VSS VSS nch w=0.205u l=0.06u
MI236 net099 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net265 VSS nch w=0.195u l=0.06u
MI163 net109 SA net093 VSS nch w=0.175u l=0.06u
MI160 net265 DA net109 VSS nch w=0.175u l=0.06u
MI218-M_u2 QN net098 VSS VSS nch w=0.39u l=0.06u
MI241-M_u2 net0124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0122 SA VSS VSS nch w=0.195u l=0.06u
MI228-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI214-M_u2 net098 net82 VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 net086 d0 VSS VSS nch w=0.195u l=0.06u
MI29 net82 INCPB net074 VSS nch w=0.15u l=0.06u
MI41 net074 net098 VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SDFXD2 DA DB SA SI SE CP Q QN VDD VSS
MI218-M_u3 QN net098 VDD VDD pch w=1.04u l=0.06u
MI241-M_u3 Q net82 VDD VDD pch w=1.04u l=0.06u
MI243-M_u3 net0124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0122 SA VDD VDD pch w=0.26u l=0.06u
MI214-M_u3 net098 net82 VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 net086 d0 VDD VDD pch w=0.26u l=0.06u
MI231 net0147 SE VDD VDD pch w=0.35u l=0.06u
MI233 net208 SA net0145 VDD pch w=0.435u l=0.06u
MI232 net0145 DB net0147 VDD pch w=0.255u l=0.06u
MI102 net144 net086 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net144 VDD pch w=0.15u l=0.06u
MI223 net82 INCPB net0171 VDD pch w=0.27u l=0.06u
MI234 net208 net0124 net0148 VDD pch w=0.2u l=0.06u
MI235 net0148 SI VDD VDD pch w=0.2u l=0.06u
MI222 net0171 net086 VDD VDD pch w=0.27u l=0.06u
MI150 net208 DA net162 VDD pch w=0.35u l=0.06u
MI151 net162 net0122 net0147 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net208 VDD pch w=0.3u l=0.06u
MI38 net82 INCP net070 VDD pch w=0.15u l=0.06u
MI24 net070 net098 VDD VDD pch w=0.15u l=0.06u
MI237 net265 SE net099 VSS nch w=0.15u l=0.06u
MI238 net265 net0122 net096 VSS nch w=0.175u l=0.06u
MI239 net096 DB net093 VSS nch w=0.175u l=0.06u
MI227 net82 INCP net0118 VSS nch w=0.22u l=0.06u
MI240 net093 net0124 VSS VSS nch w=0.355u l=0.06u
MI119 net79 net086 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net79 VSS nch w=0.15u l=0.06u
MI225 net0118 net086 VSS VSS nch w=0.205u l=0.06u
MI236 net099 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net265 VSS nch w=0.195u l=0.06u
MI163 net109 SA net093 VSS nch w=0.175u l=0.06u
MI160 net265 DA net109 VSS nch w=0.175u l=0.06u
MI218-M_u2 QN net098 VSS VSS nch w=0.78u l=0.06u
MI241-M_u2 Q net82 VSS VSS nch w=0.78u l=0.06u
MI243-M_u2 net0124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0122 SA VSS VSS nch w=0.195u l=0.06u
MI214-M_u2 net098 net82 VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 net086 d0 VSS VSS nch w=0.195u l=0.06u
MI29 net82 INCPB net074 VSS nch w=0.15u l=0.06u
MI41 net074 net098 VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SDFXD4 DA DB SA SI SE CP Q QN VDD VSS
MI231 net0147 SE VDD VDD pch w=0.35u l=0.06u
MI250 net82 INCPB net0176 VDD pch w=0.27u l=0.06u
MI251 net0176 net086 VDD VDD pch w=0.27u l=0.06u
MI233 net208 SA net0145 VDD pch w=0.435u l=0.06u
MI232 net0145 DB net0147 VDD pch w=0.255u l=0.06u
MI102 net144 net086 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net144 VDD pch w=0.15u l=0.06u
MI223 net82 INCPB net0171 VDD pch w=0.4u l=0.06u
MI234 net208 net0124 net0148 VDD pch w=0.2u l=0.06u
MI235 net0148 SI VDD VDD pch w=0.2u l=0.06u
MI222 net0171 net086 VDD VDD pch w=0.3u l=0.06u
MI150 net208 DA net162 VDD pch w=0.35u l=0.06u
MI151 net162 net0122 net0147 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net208 VDD pch w=0.35u l=0.06u
MI260-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI256-M_u3 QN net098 VDD VDD pch w=0.52u l=0.06u
MI242-M_u3 QN net098 VDD VDD pch w=0.52u l=0.06u
MI265-M_u3 net0124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0122 SA VDD VDD pch w=0.26u l=0.06u
MI254-M_u3 QN net098 VDD VDD pch w=0.52u l=0.06u
MI255-M_u3 QN net098 VDD VDD pch w=0.52u l=0.06u
MI259-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI258-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI263-M_u3 INCPB CP VDD VDD pch w=0.42u l=0.06u
MI257-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI214-M_u3 net098 net82 VDD VDD pch w=0.46u l=0.06u
MI264-M_u3 INCP INCPB VDD VDD pch w=0.49u l=0.06u
MI123-M_u3 net086 d0 VDD VDD pch w=0.29u l=0.06u
MI38 net82 INCP net070 VDD pch w=0.15u l=0.06u
MI24 net070 net098 VDD VDD pch w=0.15u l=0.06u
MI237 net265 SE net099 VSS nch w=0.15u l=0.06u
MI238 net265 net0122 net096 VSS nch w=0.175u l=0.06u
MI239 net096 DB net093 VSS nch w=0.175u l=0.06u
MI227 net82 INCP net0118 VSS nch w=0.33u l=0.06u
MI248 net82 INCP net0104 VSS nch w=0.245u l=0.06u
MI249 net0104 net086 VSS VSS nch w=0.33u l=0.06u
MI240 net093 net0124 VSS VSS nch w=0.355u l=0.06u
MI119 net79 net086 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net79 VSS nch w=0.15u l=0.06u
MI225 net0118 net086 VSS VSS nch w=0.33u l=0.06u
MI236 net099 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net265 VSS nch w=0.195u l=0.06u
MI163 net109 SA net093 VSS nch w=0.175u l=0.06u
MI160 net265 DA net109 VSS nch w=0.175u l=0.06u
MI260-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI256-M_u2 QN net098 VSS VSS nch w=0.39u l=0.06u
MI242-M_u2 QN net098 VSS VSS nch w=0.39u l=0.06u
MI265-M_u2 net0124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0122 SA VSS VSS nch w=0.195u l=0.06u
MI254-M_u2 QN net098 VSS VSS nch w=0.39u l=0.06u
MI255-M_u2 QN net098 VSS VSS nch w=0.39u l=0.06u
MI259-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI258-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI263-M_u2 INCPB CP VSS VSS nch w=0.31u l=0.06u
MI257-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI214-M_u2 net098 net82 VSS VSS nch w=0.39u l=0.06u
MI264-M_u2 INCP INCPB VSS VSS nch w=0.28u l=0.06u
MI123-M_u2 net086 d0 VSS VSS nch w=0.2u l=0.06u
MI29 net82 INCPB net074 VSS nch w=0.16u l=0.06u
MI41 net074 net098 VSS VSS nch w=0.16u l=0.06u
.ends
.subckt SDFXQD0 DA DB SA SI SE CP Q VDD VSS
MI185 d1 INCPB net278 VDD pch w=0.44u l=0.06u
MI156 net193 SA VDD VDD pch w=0.24u l=0.06u
MI136 net220 Q VDD VDD pch w=0.15u l=0.06u
MI155 net188 net235 VDD VDD pch w=0.24u l=0.06u
MI154 net255 DB net193 VDD pch w=0.24u l=0.06u
MI153 d0 INCP net197 VDD pch w=0.3u l=0.06u
MI152 net197 net233 net199 VDD pch w=0.26u l=0.06u
MI151 net208 SE VDD VDD pch w=0.26u l=0.06u
MI157 net255 DA net188 VDD pch w=0.24u l=0.06u
MI150 net197 net255 net208 VDD pch w=0.26u l=0.06u
MI149 net199 net0110 VDD VDD pch w=0.26u l=0.06u
MI103 d0 INCPB net214 VDD pch w=0.15u l=0.06u
MI186 net278 INCP net220 VDD pch w=0.15u l=0.06u
MI102 net214 d1 VDD VDD pch w=0.15u l=0.06u
MI189-M_u3 net0110 SI VDD VDD pch w=0.15u l=0.06u
MI181-M_u3 Q net278 VDD VDD pch w=0.26u l=0.06u
MI170-M_u3 net235 SA VDD VDD pch w=0.2u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI123-M_u3 d1 d0 VDD VDD pch w=0.34u l=0.06u
MI169-M_u3 net233 SE VDD VDD pch w=0.2u l=0.06u
MI190-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI189-M_u2 net0110 SI VSS VSS nch w=0.15u l=0.06u
MI181-M_u2 Q net278 VSS VSS nch w=0.195u l=0.06u
MI170-M_u2 net235 SA VSS VSS nch w=0.15u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 d1 d0 VSS VSS nch w=0.34u l=0.06u
MI169-M_u2 net233 SE VSS VSS nch w=0.15u l=0.06u
MI190-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI161 net240 SE net264 VSS nch w=0.195u l=0.06u
MI163 net246 net233 VSS VSS nch w=0.195u l=0.06u
MI167 net258 net235 VSS VSS nch w=0.195u l=0.06u
MI164 d0 INCPB net240 VSS nch w=0.2u l=0.06u
MI166 net255 DA net254 VSS nch w=0.195u l=0.06u
MI162 net264 net0110 VSS VSS nch w=0.195u l=0.06u
MI178 d1 INCP net278 VSS nch w=0.22u l=0.06u
MI135 net278 INCPB net267 VSS nch w=0.15u l=0.06u
MI168 net255 DB net258 VSS nch w=0.195u l=0.06u
MI165 net254 SA VSS VSS nch w=0.195u l=0.06u
MI120 d0 INCP net269 VSS nch w=0.15u l=0.06u
MI160 net240 net255 net246 VSS nch w=0.195u l=0.06u
MI119 net269 d1 VSS VSS nch w=0.15u l=0.06u
MI122 net267 Q VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SDFXQD1 DA DB SA SI SE CP Q VDD VSS
MI240 net153 net124 VSS VSS nch w=0.355u l=0.06u
MI119 net145 net146 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net145 VSS nch w=0.15u l=0.06u
MI225 net139 net146 VSS VSS nch w=0.205u l=0.06u
MI237 net160 SE net136 VSS nch w=0.15u l=0.06u
MI236 net136 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net160 VSS nch w=0.195u l=0.06u
MI238 net160 net122 net156 VSS nch w=0.175u l=0.06u
MI163 net126 SA net153 VSS nch w=0.175u l=0.06u
MI160 net160 DA net126 VSS nch w=0.175u l=0.06u
MI239 net156 DB net153 VSS nch w=0.175u l=0.06u
MI227 net94 INCP net139 VSS nch w=0.22u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 net146 d0 VSS VSS nch w=0.195u l=0.06u
MI194-M_u2 net124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net122 SA VSS VSS nch w=0.195u l=0.06u
MI228-M_u2 Q net94 VSS VSS nch w=0.39u l=0.06u
MI193-M_u2 net164 net94 VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI29 net94 INCPB net165 VSS nch w=0.15u l=0.06u
MI41 net165 net164 VSS VSS nch w=0.15u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 net146 d0 VDD VDD pch w=0.26u l=0.06u
MI194-M_u3 net124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net122 SA VDD VDD pch w=0.26u l=0.06u
MI228-M_u3 Q net94 VDD VDD pch w=0.52u l=0.06u
MI193-M_u3 net164 net94 VDD VDD pch w=0.15u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI231 net105 SE VDD VDD pch w=0.35u l=0.06u
MI233 net91 SA net103 VDD pch w=0.435u l=0.06u
MI232 net103 DB net105 VDD pch w=0.255u l=0.06u
MI102 net100 net146 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net100 VDD pch w=0.15u l=0.06u
MI223 net94 INCPB net96 VDD pch w=0.27u l=0.06u
MI234 net91 net124 net88 VDD pch w=0.2u l=0.06u
MI235 net88 SI VDD VDD pch w=0.2u l=0.06u
MI222 net96 net146 VDD VDD pch w=0.27u l=0.06u
MI150 net91 DA net84 VDD pch w=0.35u l=0.06u
MI151 net84 net122 net105 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net91 VDD pch w=0.3u l=0.06u
MI38 net94 INCP net173 VDD pch w=0.15u l=0.06u
MI24 net173 net164 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt SDFXQD2 DA DB SA SI SE CP Q VDD VSS
MI241-M_u3 Q net82 VDD VDD pch w=1.04u l=0.06u
MI243-M_u3 net0124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0122 SA VDD VDD pch w=0.26u l=0.06u
MI214-M_u3 net098 net82 VDD VDD pch w=0.15u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 net086 d0 VDD VDD pch w=0.26u l=0.06u
MI231 net0147 SE VDD VDD pch w=0.35u l=0.06u
MI233 net208 SA net0145 VDD pch w=0.435u l=0.06u
MI232 net0145 DB net0147 VDD pch w=0.255u l=0.06u
MI102 net144 net086 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net144 VDD pch w=0.15u l=0.06u
MI223 net82 INCPB net0171 VDD pch w=0.27u l=0.06u
MI234 net208 net0124 net0148 VDD pch w=0.2u l=0.06u
MI235 net0148 SI VDD VDD pch w=0.2u l=0.06u
MI222 net0171 net086 VDD VDD pch w=0.27u l=0.06u
MI150 net208 DA net162 VDD pch w=0.35u l=0.06u
MI151 net162 net0122 net0147 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net208 VDD pch w=0.3u l=0.06u
MI38 net82 INCP net070 VDD pch w=0.15u l=0.06u
MI24 net070 net098 VDD VDD pch w=0.15u l=0.06u
MI237 net265 SE net099 VSS nch w=0.15u l=0.06u
MI238 net265 net0122 net096 VSS nch w=0.175u l=0.06u
MI239 net096 DB net093 VSS nch w=0.175u l=0.06u
MI227 net82 INCP net0118 VSS nch w=0.22u l=0.06u
MI240 net093 net0124 VSS VSS nch w=0.355u l=0.06u
MI119 net79 net086 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net79 VSS nch w=0.15u l=0.06u
MI225 net0118 net086 VSS VSS nch w=0.205u l=0.06u
MI236 net099 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net265 VSS nch w=0.195u l=0.06u
MI163 net109 SA net093 VSS nch w=0.175u l=0.06u
MI160 net265 DA net109 VSS nch w=0.175u l=0.06u
MI241-M_u2 Q net82 VSS VSS nch w=0.78u l=0.06u
MI243-M_u2 net0124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0122 SA VSS VSS nch w=0.195u l=0.06u
MI214-M_u2 net098 net82 VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 net086 d0 VSS VSS nch w=0.195u l=0.06u
MI29 net82 INCPB net074 VSS nch w=0.15u l=0.06u
MI41 net074 net098 VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SDFXQD4 DA DB SA SI SE CP Q VDD VSS
MI231 net0147 SE VDD VDD pch w=0.35u l=0.06u
MI250 net82 INCPB net0176 VDD pch w=0.27u l=0.06u
MI251 net0176 net086 VDD VDD pch w=0.27u l=0.06u
MI233 net208 SA net0145 VDD pch w=0.435u l=0.06u
MI232 net0145 DB net0147 VDD pch w=0.255u l=0.06u
MI102 net144 net086 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net144 VDD pch w=0.15u l=0.06u
MI223 net82 INCPB net0171 VDD pch w=0.4u l=0.06u
MI234 net208 net0124 net0148 VDD pch w=0.2u l=0.06u
MI235 net0148 SI VDD VDD pch w=0.2u l=0.06u
MI222 net0171 net086 VDD VDD pch w=0.3u l=0.06u
MI150 net208 DA net162 VDD pch w=0.35u l=0.06u
MI151 net162 net0122 net0147 VDD pch w=0.35u l=0.06u
MI153 d0 INCP net208 VDD pch w=0.35u l=0.06u
MI260-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI264-M_u3 INCP INCPB VDD VDD pch w=0.49u l=0.06u
MI263-M_u3 INCPB CP VDD VDD pch w=0.42u l=0.06u
MI265-M_u3 net0124 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0122 SA VDD VDD pch w=0.26u l=0.06u
MI259-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI258-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI257-M_u3 Q net82 VDD VDD pch w=0.52u l=0.06u
MI214-M_u3 net098 net82 VDD VDD pch w=0.15u l=0.06u
MI123-M_u3 net086 d0 VDD VDD pch w=0.29u l=0.06u
MI38 net82 INCP net070 VDD pch w=0.15u l=0.06u
MI24 net070 net098 VDD VDD pch w=0.15u l=0.06u
MI237 net265 SE net099 VSS nch w=0.15u l=0.06u
MI238 net265 net0122 net096 VSS nch w=0.175u l=0.06u
MI239 net096 DB net093 VSS nch w=0.175u l=0.06u
MI227 net82 INCP net0118 VSS nch w=0.33u l=0.06u
MI248 net82 INCP net0104 VSS nch w=0.245u l=0.06u
MI249 net0104 net086 VSS VSS nch w=0.33u l=0.06u
MI240 net093 net0124 VSS VSS nch w=0.355u l=0.06u
MI119 net79 net086 VSS VSS nch w=0.15u l=0.06u
MI120 d0 INCP net79 VSS nch w=0.15u l=0.06u
MI225 net0118 net086 VSS VSS nch w=0.33u l=0.06u
MI236 net099 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net265 VSS nch w=0.195u l=0.06u
MI163 net109 SA net093 VSS nch w=0.175u l=0.06u
MI160 net265 DA net109 VSS nch w=0.175u l=0.06u
MI260-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI264-M_u2 INCP INCPB VSS VSS nch w=0.28u l=0.06u
MI263-M_u2 INCPB CP VSS VSS nch w=0.31u l=0.06u
MI265-M_u2 net0124 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0122 SA VSS VSS nch w=0.195u l=0.06u
MI259-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI258-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI257-M_u2 Q net82 VSS VSS nch w=0.39u l=0.06u
MI214-M_u2 net098 net82 VSS VSS nch w=0.16u l=0.06u
MI123-M_u2 net086 d0 VSS VSS nch w=0.2u l=0.06u
MI29 net82 INCPB net074 VSS nch w=0.16u l=0.06u
MI41 net074 net098 VSS VSS nch w=0.16u l=0.06u
.ends
.subckt SEDFCND0 E SE CP SI D CDN Q QN VDD VSS
MI191-M_u2 net78 CDN VDD VDD pch w=0.4u l=0.06u
MI191-M_u1 net78 net139 VDD VDD pch w=0.4u l=0.06u
MI178 net156 net134 net139 VDD pch w=0.15u l=0.06u
MI153 d0 net134 net87 VDD pch w=0.25u l=0.06u
MI150 net87 D net96 VDD pch w=0.47u l=0.06u
MI233 net87 E net90 VDD pch w=0.375u l=0.06u
MI151 net96 net130 net92 VDD pch w=0.32u l=0.06u
MI179 d1 INCPB net139 VDD pch w=0.39u l=0.06u
MI232 net90 net156 net92 VDD pch w=0.255u l=0.06u
MI234 net87 net120 net89 VDD pch w=0.15u l=0.06u
MI231 net92 SE VDD VDD pch w=0.32u l=0.06u
MI235 net89 SI VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net119 VDD pch w=0.15u l=0.06u
MI102 net119 d1 VDD VDD pch w=0.15u l=0.06u
MI101 net119 CDN VDD VDD pch w=0.15u l=0.06u
MI192-M_u3 net130 E VDD VDD pch w=0.2u l=0.06u
MI189-M_u3 QN net156 VDD VDD pch w=0.26u l=0.06u
MI177-M_u3 net156 net78 VDD VDD pch w=0.2u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI188-M_u3 Q net78 VDD VDD pch w=0.26u l=0.06u
MI230-M_u3 net120 SE VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 net134 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI191-M_u4 XI191-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI191-M_u3 net78 net139 XI191-net6 VSS nch w=0.23u l=0.06u
MI192-M_u2 net130 E VSS VSS nch w=0.15u l=0.06u
MI189-M_u2 QN net156 VSS VSS nch w=0.195u l=0.06u
MI177-M_u2 net156 net78 VSS VSS nch w=0.15u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI188-M_u2 Q net78 VSS VSS nch w=0.195u l=0.06u
MI230-M_u2 net120 SE VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 net134 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI173 net156 INCPB net139 VSS nch w=0.15u l=0.06u
MI119 net167 d1 net166 VSS nch w=0.15u l=0.06u
MI240 net154 net120 VSS VSS nch w=0.355u l=0.06u
MI120 d0 net134 net167 VSS nch w=0.15u l=0.06u
MI236 net151 SI VSS VSS nch w=0.15u l=0.06u
MI239 net145 net156 net154 VSS nch w=0.175u l=0.06u
MI237 net152 SE net151 VSS nch w=0.15u l=0.06u
MI163 net149 E net154 VSS nch w=0.355u l=0.06u
MI238 net152 net130 net145 VSS nch w=0.175u l=0.06u
MI160 net152 D net149 VSS nch w=0.26u l=0.06u
MI174 d1 net134 net139 VSS nch w=0.17u l=0.06u
MI164 d0 INCPB net152 VSS nch w=0.34u l=0.06u
MI118 net166 CDN VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFCND1 E SE CP SI D CDN Q QN VDD VSS
MI237 net076 SE net0102 VSS nch w=0.15u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI188-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI189-M_u2 QN net0124 VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.195u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI193-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MI192-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 net0122 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI191-M_u4 XI191-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI191-M_u3 net077 net76 XI191-net6 VSS nch w=0.23u l=0.06u
MI188-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI189-M_u3 QN net0124 VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI193-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MI192-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 net0122 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.25u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.15u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.15u l=0.06u
MI191-M_u2 net077 CDN VDD VDD pch w=0.4u l=0.06u
MI191-M_u1 net077 net76 VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SEDFCND2 E SE CP SI D CDN Q QN VDD VSS
MI237 net076 SE net0102 VSS nch w=0.15u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI193-M_u2 QN net0124 VSS VSS nch w=0.39u l=0.06u
MI197-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MI194-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI195-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI192-M_u2 QN net0124 VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.195u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI198-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 net0122 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI196-M_u4 XI196-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI196-M_u3 net077 net76 XI196-net6 VSS nch w=0.23u l=0.06u
MI193-M_u3 QN net0124 VDD VDD pch w=0.52u l=0.06u
MI197-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MI194-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI195-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI192-M_u3 QN net0124 VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI198-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 net0122 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.25u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.15u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.15u l=0.06u
MI196-M_u2 net077 CDN VDD VDD pch w=0.4u l=0.06u
MI196-M_u1 net077 net76 VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SEDFCND4 E SE CP SI D CDN Q QN VDD VSS
MI237 net076 SE net0102 VSS nch w=0.15u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI188-M_u2 Q net077 VSS VSS nch w=1.56u l=0.06u
MI189-M_u2 QN net0124 VSS VSS nch w=1.56u l=0.06u
MI201-M_u2 net0122 INCPB VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.19u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI203-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MI202-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI183-M_u4 XI183-net6 net76 VSS VSS nch w=0.225u l=0.06u
MI183-M_u3 net077 CDN XI183-net6 VSS nch w=0.225u l=0.06u
MI197-M_u4 XI197-net6 net76 VSS VSS nch w=0.225u l=0.06u
MI197-M_u3 net077 CDN XI197-net6 VSS nch w=0.225u l=0.06u
MI188-M_u3 Q net077 VDD VDD pch w=2.08u l=0.06u
MI189-M_u3 QN net0124 VDD VDD pch w=2.08u l=0.06u
MI201-M_u3 net0122 INCPB VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI203-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MI202-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.34u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.15u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.15u l=0.06u
MI183-M_u2 net077 net76 VDD VDD pch w=0.52u l=0.06u
MI183-M_u1 net077 CDN VDD VDD pch w=0.52u l=0.06u
MI197-M_u2 net077 net76 VDD VDD pch w=0.52u l=0.06u
MI197-M_u1 net077 CDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SEDFCNQD0 E SE CP SI D CDN Q VDD VSS
MI191-M_u2 net76 CDN VDD VDD pch w=0.4u l=0.06u
MI191-M_u1 net76 net156 VDD VDD pch w=0.4u l=0.06u
MI178 net149 net124 net156 VDD pch w=0.15u l=0.06u
MI179 d1 INCPB net156 VDD pch w=0.39u l=0.06u
MI153 d0 net124 net85 VDD pch w=0.25u l=0.06u
MI150 net85 D net91 VDD pch w=0.47u l=0.06u
MI233 net85 E net88 VDD pch w=0.2u l=0.06u
MI151 net91 net120 net90 VDD pch w=0.32u l=0.06u
MI103 d0 INCPB net117 VDD pch w=0.15u l=0.06u
MI232 net88 net149 net90 VDD pch w=0.2u l=0.06u
MI234 net85 net118 net87 VDD pch w=0.15u l=0.06u
MI231 net90 SE VDD VDD pch w=0.32u l=0.06u
MI235 net87 SI VDD VDD pch w=0.15u l=0.06u
MI102 net117 d1 VDD VDD pch w=0.15u l=0.06u
MI101 net117 CDN VDD VDD pch w=0.15u l=0.06u
MI188-M_u3 Q net76 VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 net124 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI197-M_u3 net120 E VDD VDD pch w=0.2u l=0.06u
MI198-M_u3 net118 SE VDD VDD pch w=0.2u l=0.06u
MI177-M_u3 net149 net76 VDD VDD pch w=0.2u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI191-M_u4 XI191-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI191-M_u3 net76 net156 XI191-net6 VSS nch w=0.23u l=0.06u
MI188-M_u2 Q net76 VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 net124 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI197-M_u2 net120 E VSS VSS nch w=0.15u l=0.06u
MI198-M_u2 net118 SE VSS VSS nch w=0.15u l=0.06u
MI177-M_u2 net149 net76 VSS VSS nch w=0.15u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI173 net149 INCPB net156 VSS nch w=0.15u l=0.06u
MI119 net163 d1 net169 VSS nch w=0.15u l=0.06u
MI120 d0 net124 net163 VSS nch w=0.15u l=0.06u
MI174 d1 net124 net156 VSS nch w=0.17u l=0.06u
MI240 net147 net118 VSS VSS nch w=0.355u l=0.06u
MI236 net151 SI VSS VSS nch w=0.15u l=0.06u
MI239 net148 net149 net147 VSS nch w=0.175u l=0.06u
MI237 net145 SE net151 VSS nch w=0.15u l=0.06u
MI163 net135 E net147 VSS nch w=0.355u l=0.06u
MI238 net145 net120 net148 VSS nch w=0.175u l=0.06u
MI160 net145 D net135 VSS nch w=0.26u l=0.06u
MI164 d0 INCPB net145 VSS nch w=0.34u l=0.06u
MI118 net169 CDN VSS VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFCNQD1 E SE CP SI D CDN Q VDD VSS
MI237 net076 SE net0102 VSS nch w=0.15u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI188-M_u2 Q net077 VSS VSS nch w=0.39u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.195u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI193-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MI192-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 net0122 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI191-M_u4 XI191-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI191-M_u3 net077 net76 XI191-net6 VSS nch w=0.23u l=0.06u
MI188-M_u3 Q net077 VDD VDD pch w=0.52u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI193-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MI192-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 net0122 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.25u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.2u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.2u l=0.06u
MI191-M_u2 net077 CDN VDD VDD pch w=0.4u l=0.06u
MI191-M_u1 net077 net76 VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SEDFCNQD2 E SE CP SI D CDN Q VDD VSS
MI237 net076 SE net0102 VSS nch w=0.19u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.19u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI188-M_u2 Q net077 VSS VSS nch w=0.78u l=0.06u
MI193-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.195u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI194-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 net0122 INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI192-M_u4 XI192-net6 CDN VSS VSS nch w=0.23u l=0.06u
MI192-M_u3 net077 net76 XI192-net6 VSS nch w=0.23u l=0.06u
MI188-M_u3 Q net077 VDD VDD pch w=1.04u l=0.06u
MI193-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI194-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 net0122 INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.25u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.26u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.26u l=0.06u
MI192-M_u2 net077 CDN VDD VDD pch w=0.4u l=0.06u
MI192-M_u1 net077 net76 VDD VDD pch w=0.4u l=0.06u
.ends
.subckt SEDFCNQD4 E SE CP SI D CDN Q VDD VSS
MI237 net076 SE net0102 VSS nch w=0.15u l=0.06u
MI174 d1 net0122 net76 VSS nch w=0.17u l=0.06u
MI173 net0124 INCPB net76 VSS nch w=0.15u l=0.06u
MI118 net92 CDN VSS VSS nch w=0.15u l=0.06u
MI119 net95 d1 net92 VSS nch w=0.15u l=0.06u
MI120 d0 net0122 net95 VSS nch w=0.15u l=0.06u
MI240 net096 net0126 VSS VSS nch w=0.355u l=0.06u
MI236 net0102 SI VSS VSS nch w=0.15u l=0.06u
MI164 d0 INCPB net076 VSS nch w=0.34u l=0.06u
MI163 net085 E net096 VSS nch w=0.355u l=0.06u
MI160 net076 D net085 VSS nch w=0.26u l=0.06u
MI238 net076 net0103 net099 VSS nch w=0.175u l=0.06u
MI239 net099 net0124 net096 VSS nch w=0.175u l=0.06u
MI188-M_u2 Q net077 VSS VSS nch w=1.56u l=0.06u
MI196-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI198-M_u2 net0103 E VSS VSS nch w=0.195u l=0.06u
MI177-M_u2 net0124 net077 VSS VSS nch w=0.19u l=0.06u
MI190-M_u2 d1 d0 VSS VSS nch w=0.21u l=0.06u
MI230-M_u2 net0126 SE VSS VSS nch w=0.195u l=0.06u
MI197-M_u2 net0122 INCPB VSS VSS nch w=0.39u l=0.06u
MI183-M_u4 XI183-net6 net76 VSS VSS nch w=0.23u l=0.06u
MI183-M_u3 net077 CDN XI183-net6 VSS nch w=0.23u l=0.06u
MI194-M_u4 XI194-net6 net76 VSS VSS nch w=0.23u l=0.06u
MI194-M_u3 net077 CDN XI194-net6 VSS nch w=0.23u l=0.06u
MI188-M_u3 Q net077 VDD VDD pch w=2.08u l=0.06u
MI196-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI198-M_u3 net0103 E VDD VDD pch w=0.26u l=0.06u
MI177-M_u3 net0124 net077 VDD VDD pch w=0.26u l=0.06u
MI190-M_u3 d1 d0 VDD VDD pch w=0.21u l=0.06u
MI230-M_u3 net0126 SE VDD VDD pch w=0.26u l=0.06u
MI197-M_u3 net0122 INCPB VDD VDD pch w=0.52u l=0.06u
MI231 net0153 SE VDD VDD pch w=0.32u l=0.06u
MI233 net0148 E net0151 VDD pch w=0.375u l=0.06u
MI101 net83 CDN VDD VDD pch w=0.15u l=0.06u
MI178 net0124 net0122 net76 VDD pch w=0.15u l=0.06u
MI102 net83 d1 VDD VDD pch w=0.15u l=0.06u
MI103 d0 INCPB net83 VDD pch w=0.15u l=0.06u
MI150 net0148 D net0144 VDD pch w=0.47u l=0.06u
MI179 d1 INCPB net76 VDD pch w=0.39u l=0.06u
MI232 net0151 net0124 net0153 VDD pch w=0.255u l=0.06u
MI151 net0144 net0103 net0153 VDD pch w=0.32u l=0.06u
MI153 d0 net0122 net0148 VDD pch w=0.34u l=0.06u
MI234 net0148 net0126 net0145 VDD pch w=0.2u l=0.06u
MI235 net0145 SI VDD VDD pch w=0.2u l=0.06u
MI183-M_u2 net077 net76 VDD VDD pch w=0.52u l=0.06u
MI183-M_u1 net077 CDN VDD VDD pch w=0.52u l=0.06u
MI194-M_u2 net077 net76 VDD VDD pch w=0.52u l=0.06u
MI194-M_u1 net077 CDN VDD VDD pch w=0.52u l=0.06u
.ends
.subckt SEDFD0 E SE CP SI D Q QN VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.26u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI228-M_u3 QN SLO VDD VDD pch w=0.26u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.2u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.195u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI228-M_u2 QN SLO VSS VSS nch w=0.195u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.15u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFD1 E SE CP SI D Q QN VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFD2 E SE CP SI D Q QN VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI236-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI237-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI236-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI237-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFD4 E SE CP SI D Q QN VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI236-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI237-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI238-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI239-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI243-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI240-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI241-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI245-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI242-M_u3 SLO SLI VDD VDD pch w=0.52u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MI244-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI236-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI237-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI238-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI239-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI243-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI240-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI241-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI245-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI242-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MI244-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFKCND0 SI D E SE CP CN Q QN VDD VSS
MI146 net84 CN VSS VSS nch w=0.15u l=0.06u
MI144 net189 D net086 VSS nch w=0.37u l=0.06u
MI145 net086 E net84 VSS nch w=0.15u l=0.06u
MI143 net95 net185 net84 VSS nch w=0.37u l=0.06u
MI113 net189 net101 net95 VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI64 net102 net93 VSS VSS nch w=0.275u l=0.06u
MI65 net193 net163 net102 VSS nch w=0.275u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI135-M_u2 Q net156 VSS VSS nch w=0.195u l=0.06u
MI148-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI48-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.15u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI138-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI149-M_u2 net185 net156 VSS VSS nch w=0.15u l=0.06u
MI130-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI147-M_u2 QN net185 VSS VSS nch w=0.195u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.15u l=0.06u
MI135-M_u3 Q net156 VDD VDD pch w=0.26u l=0.06u
MI148-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI48-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.2u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI138-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI149-M_u3 net185 net156 VDD VDD pch w=0.2u l=0.06u
MI130-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI147-M_u3 QN net185 VDD VDD pch w=0.26u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.2u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI140 net0150 net185 VDD VDD pch w=0.21u l=0.06u
MI142 net189 CN VDD VDD pch w=0.2u l=0.06u
MI141 net189 E net0150 VDD pch w=0.21u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI50 net174 SE VDD VDD pch w=0.355u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.15u l=0.06u
MI51 net145 net163 net174 VDD pch w=0.175u l=0.06u
MI52 net72 SI VDD VDD pch w=0.15u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
MI139 net189 D net151 VDD pch w=0.34u l=0.06u
.ends
.subckt SEDFKCND1 SI D E SE CP CN Q QN VDD VSS
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI153 net189 net101 net087 VSS nch w=0.37u l=0.06u
MI154 net087 net185 net84 VSS nch w=0.37u l=0.06u
MI112 net84 CN VSS VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI152 net87 E net84 VSS nch w=0.19u l=0.06u
MI143-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI157-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI158-M_u2 net185 net156 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI132-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI143-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI157-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI158-M_u3 net185 net156 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI132-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI149 net0151 net185 VDD VDD pch w=0.21u l=0.06u
MI150 net189 E net0151 VDD pch w=0.21u l=0.06u
MI146 net189 D net151 VDD pch w=0.34u l=0.06u
MI155 net189 CN VDD VDD pch w=0.36u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.15u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.15u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt SEDFKCND2 SI D E SE CP CN Q QN VDD VSS
MI158 net84 CN VSS VSS nch w=0.37u l=0.06u
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI153 net189 net101 net087 VSS nch w=0.37u l=0.06u
MI154 net087 net185 net84 VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI152 net87 E net84 VSS nch w=0.19u l=0.06u
MI156-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI157-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI162-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI160-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI161-M_u2 net185 net156 VSS VSS nch w=0.195u l=0.06u
MI130-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI132-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI156-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI157-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI162-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI160-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI161-M_u3 net185 net156 VDD VDD pch w=0.26u l=0.06u
MI130-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI132-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI149 net0151 net185 VDD VDD pch w=0.21u l=0.06u
MI150 net189 E net0151 VDD pch w=0.21u l=0.06u
MI146 net189 D net151 VDD pch w=0.34u l=0.06u
MI155 net189 CN VDD VDD pch w=0.36u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.175u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.175u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt SEDFKCND4 SI D E SE CP CN Q QN VDD VSS
MI158 net84 CN VSS VSS nch w=0.37u l=0.06u
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI153 net189 net101 net087 VSS nch w=0.37u l=0.06u
MI154 net087 net185 net84 VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI152 net87 E net84 VSS nch w=0.19u l=0.06u
MI156-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI159-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI157-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI160-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI161-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI162-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI163-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI169-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI166-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI164-M_u2 net185 net156 VSS VSS nch w=0.78u l=0.06u
MI130-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI132-M_u2 QN net185 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI156-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI159-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI157-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI160-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI161-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI162-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI163-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI169-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI166-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI164-M_u3 net185 net156 VDD VDD pch w=1.04u l=0.06u
MI130-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI132-M_u3 QN net185 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI149 net0151 net185 VDD VDD pch w=0.21u l=0.06u
MI150 net189 E net0151 VDD pch w=0.21u l=0.06u
MI146 net189 D net151 VDD pch w=0.34u l=0.06u
MI155 net189 CN VDD VDD pch w=0.36u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.41u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.175u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.175u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
.ends
.subckt SEDFKCNQD0 SI D E SE CP CN Q VDD VSS
MI145-M_u2 net081 SI VSS VSS nch w=0.15u l=0.06u
MI148-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI146-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.34u l=0.06u
MI130-M_u2 Q net83 VSS VSS nch w=0.375u l=0.06u
MI147-M_u2 net101 E VSS VSS nch w=0.15u l=0.06u
MI141 net95 Q net84 VSS nch w=0.195u l=0.06u
MI143 net099 E net84 VSS nch w=0.17u l=0.06u
MI144 net84 CN VSS VSS nch w=0.15u l=0.06u
MI142 net189 D net099 VSS nch w=0.195u l=0.06u
MI113 net189 net101 net95 VSS nch w=0.195u l=0.06u
MI29 net83 INCPB net083 VSS nch w=0.15u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.18u l=0.06u
MI39 net083 Q VSS VSS nch w=0.15u l=0.06u
MI64 net102 net93 VSS VSS nch w=0.195u l=0.06u
MI65 net193 net189 net102 VSS nch w=0.195u l=0.06u
MI62 net193 SE net129 VSS nch w=0.195u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.23u l=0.06u
MI63 net129 net081 VSS VSS nch w=0.195u l=0.06u
MI145-M_u3 net081 SI VDD VDD pch w=0.2u l=0.06u
MI148-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.29u l=0.06u
MI146-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.34u l=0.06u
MI130-M_u3 Q net83 VDD VDD pch w=0.52u l=0.06u
MI147-M_u3 net101 E VDD VDD pch w=0.2u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.26u l=0.06u
MI139 net189 E net0146 VDD pch w=0.17u l=0.06u
MI138 net0146 Q VDD VDD pch w=0.17u l=0.06u
MI137 net189 D net151 VDD pch w=0.26u l=0.06u
MI38 net83 INCP net091 VDD pch w=0.15u l=0.06u
MI24 net091 Q VDD VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.43u l=0.06u
MI50 net174 SE VDD VDD pch w=0.255u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.3u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.255u l=0.06u
MI51 net145 net189 net174 VDD pch w=0.255u l=0.06u
MI52 net72 net081 VDD VDD pch w=0.255u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
MI140 net189 CN VDD VDD pch w=0.2u l=0.06u
.ends
.subckt SEDFKCNQD1 SI D E SE CP CN Q VDD VSS
MI149 net95 net185 net84 VSS nch w=0.37u l=0.06u
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI151 net84 CN VSS VSS nch w=0.37u l=0.06u
MI150 net87 E net84 VSS nch w=0.19u l=0.06u
MI113 net189 net101 net95 VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI143-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI152-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI153-M_u2 net185 net156 VSS VSS nch w=0.15u l=0.06u
MI130-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI143-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI152-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI153-M_u3 net185 net156 VDD VDD pch w=0.15u l=0.06u
MI130-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI147 net189 E net0150 VDD pch w=0.21u l=0.06u
MI146 net0150 net185 VDD VDD pch w=0.21u l=0.06u
MI145 net189 D net151 VDD pch w=0.34u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.26u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.175u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.175u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
MI148 net189 CN VDD VDD pch w=0.36u l=0.06u
.ends
.subckt SEDFKCNQD2 SI D E SE CP CN Q VDD VSS
MI146 net088 net185 net84 VSS nch w=0.37u l=0.06u
MI147 net87 E net84 VSS nch w=0.19u l=0.06u
MI145 net189 net101 net088 VSS nch w=0.37u l=0.06u
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI154 net84 CN VSS VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI135-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI143-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI155-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI156-M_u2 net185 net156 VSS VSS nch w=0.15u l=0.06u
MI152-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI135-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI143-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI155-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI156-M_u3 net185 net156 VDD VDD pch w=0.15u l=0.06u
MI152-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI150 net189 E net0151 VDD pch w=0.21u l=0.06u
MI149 net0151 net185 VDD VDD pch w=0.21u l=0.06u
MI148 net189 D net151 VDD pch w=0.34u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.175u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.175u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
MI151 net189 CN VDD VDD pch w=0.36u l=0.06u
.ends
.subckt SEDFKCNQD4 SI D E SE CP CN Q VDD VSS
MI146 net088 net185 net84 VSS nch w=0.37u l=0.06u
MI147 net87 E net84 VSS nch w=0.19u l=0.06u
MI145 net189 net101 net088 VSS nch w=0.37u l=0.06u
MI114 net189 D net87 VSS nch w=0.37u l=0.06u
MI154 net84 CN VSS VSS nch w=0.37u l=0.06u
MI127 net176 INCP net83 VSS nch w=0.21u l=0.06u
MI128 net185 INCPB net83 VSS nch w=0.15u l=0.06u
MI141 net193 net93 net92 VSS nch w=0.21u l=0.06u
MI65 net92 net163 VSS VSS nch w=0.39u l=0.06u
MI62 net193 SE net129 VSS nch w=0.15u l=0.06u
MI101 net175 INCP net123 VSS nch w=0.15u l=0.06u
MI102 net123 net176 VSS VSS nch w=0.15u l=0.06u
MI83 net175 INCPB net193 VSS nch w=0.25u l=0.06u
MI63 net129 SI VSS VSS nch w=0.15u l=0.06u
MI135-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI155-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI158-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI153-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI157-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI156-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI161-M_u2 net185 net156 VSS VSS nch w=0.15u l=0.06u
MI45-M_u2 net93 SE VSS VSS nch w=0.195u l=0.06u
MI42-M_u2 net176 net175 VSS VSS nch w=0.21u l=0.06u
MI105-M_u2 net163 net189 VSS VSS nch w=0.22u l=0.06u
MI152-M_u2 net156 net83 VSS VSS nch w=0.39u l=0.06u
MI131-M_u2 Q net156 VSS VSS nch w=0.39u l=0.06u
MI106-M_u2 net101 E VSS VSS nch w=0.195u l=0.06u
MI135-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI155-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI158-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI153-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI157-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI156-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI161-M_u3 net185 net156 VDD VDD pch w=0.15u l=0.06u
MI45-M_u3 net93 SE VDD VDD pch w=0.255u l=0.06u
MI42-M_u3 net176 net175 VDD VDD pch w=0.23u l=0.06u
MI105-M_u3 net163 net189 VDD VDD pch w=0.52u l=0.06u
MI152-M_u3 net156 net83 VDD VDD pch w=0.52u l=0.06u
MI131-M_u3 Q net156 VDD VDD pch w=0.52u l=0.06u
MI106-M_u3 net101 E VDD VDD pch w=0.26u l=0.06u
MI142 net145 SE net92 VDD pch w=0.355u l=0.06u
MI108 net151 net101 VDD VDD pch w=0.34u l=0.06u
MI150 net189 E net0151 VDD pch w=0.21u l=0.06u
MI149 net0151 net185 VDD VDD pch w=0.21u l=0.06u
MI148 net189 D net151 VDD pch w=0.34u l=0.06u
MI133 net185 INCP net83 VDD pch w=0.15u l=0.06u
MI134 net176 INCPB net83 VDD pch w=0.33u l=0.06u
MI82 net175 INCP net145 VDD pch w=0.34u l=0.06u
MI53 net145 net93 net72 VDD pch w=0.175u l=0.06u
MI51 net92 net163 VDD VDD pch w=0.52u l=0.06u
MI52 net72 SI VDD VDD pch w=0.175u l=0.06u
MI99 net175 INCPB net190 VDD pch w=0.15u l=0.06u
MI100 net190 net176 VDD VDD pch w=0.15u l=0.06u
MI151 net189 CN VDD VDD pch w=0.36u l=0.06u
.ends
.subckt SEDFQD0 E SE CP SI D Q VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.26u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.2u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.195u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.15u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQD1 E SE CP SI D Q VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQD2 E SE CP SI D Q VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI236-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI236-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQD4 E SE CP SI D Q VDD VSS
MI218-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI242-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI244-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI236-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI238-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI239-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MI243-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI218-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI242-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI244-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI236-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI238-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI239-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MI243-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQND0 E SE CP SI D QN VDD VSS
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI228-M_u3 QN SLO VDD VDD pch w=0.26u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.2u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI228-M_u2 QN SLO VSS VSS nch w=0.195u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.15u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQND1 E SE CP SI D QN VDD VSS
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQND2 E SE CP SI D QN VDD VSS
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI237-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI225-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MU84-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI237-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI225-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MU84-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQND4 E SE CP SI D QN VDD VSS
MI243-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI245-M_u3 SLO SLI VDD VDD pch w=0.52u l=0.06u
MI224-M_u3 net0123 SI VDD VDD pch w=0.15u l=0.06u
MI237-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI240-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI241-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI242-M_u3 SLO SLI VDD VDD pch w=0.52u l=0.06u
MI235-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI170-M_u3 net316 E VDD VDD pch w=0.26u l=0.06u
MI169-M_u3 net318 SE VDD VDD pch w=0.26u l=0.06u
MI244-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI231 net094 SLO VDD VDD pch w=0.2u l=0.06u
MI232 SLI INCP net094 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.38u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI149 net167 net0123 VDD VDD pch w=0.2u l=0.06u
MI150 net208 net314 net162 VDD pch w=0.26u l=0.06u
MI157 net314 D net161 VDD pch w=0.26u l=0.06u
MI151 net162 SE VDD VDD pch w=0.26u l=0.06u
MI152 net208 net318 net167 VDD pch w=0.2u l=0.06u
MI153 MLI INCP net208 VDD pch w=0.36u l=0.06u
MI154 net314 E net173 VDD pch w=0.26u l=0.06u
MI155 net161 net316 VDD VDD pch w=0.26u l=0.06u
MI156 net173 SLO VDD VDD pch w=0.26u l=0.06u
MI243-M_u2 INCPB CP VSS VSS nch w=0.39u l=0.06u
MI245-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI224-M_u2 net0123 SI VSS VSS nch w=0.15u l=0.06u
MI237-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI240-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI241-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI242-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI235-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI170-M_u2 net316 E VSS VSS nch w=0.195u l=0.06u
MI169-M_u2 net318 SE VSS VSS nch w=0.18u l=0.06u
MI244-M_u2 INCP INCPB VSS VSS nch w=0.39u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI233 net0135 SLO VSS VSS nch w=0.15u l=0.06u
MI234 SLI INCPB net0135 VSS nch w=0.15u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI162 net112 net0123 VSS VSS nch w=0.15u l=0.06u
MI168 net314 net316 net95 VSS nch w=0.195u l=0.06u
MI167 net95 SLO VSS VSS nch w=0.195u l=0.06u
MI166 net314 D net101 VSS nch w=0.195u l=0.06u
MI165 net101 E VSS VSS nch w=0.195u l=0.06u
MI164 MLI INCPB net265 VSS nch w=0.15u l=0.06u
MI163 net109 net318 VSS VSS nch w=0.16u l=0.06u
MI160 net265 net314 net109 VSS nch w=0.16u l=0.06u
MI161 net265 SE net112 VSS nch w=0.15u l=0.06u
.ends
.subckt SEDFQNXD0 E SE CP SI D QN VDD VSS
MI79 net110 E net107 VSS nch w=0.15u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI255 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.15u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.15u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 QN SLO VSS VSS nch w=0.195u l=0.06u
MI257-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI256 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.2u l=0.06u
MI77 VDD E net110 VDD pch w=0.2u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.2u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 QN SLO VDD VDD pch w=0.26u l=0.06u
MI257-M_u3 d5 SLO VDD VDD pch w=0.2u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.19u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQNXD1 E SE CP SI D QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI255 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI257-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI256 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI257-M_u3 d5 SLO VDD VDD pch w=0.2u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.19u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQNXD2 E SE CP SI D QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI255 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI258-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI212-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI257-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI256 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI258-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI212-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI257-M_u3 d5 SLO VDD VDD pch w=0.15u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQNXD4 E SE CP SI D QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI255 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI258-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI259-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI260-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI262-M_u2 INCPB CP VSS VSS nch w=0.29u l=0.06u
MI212-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI257-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI264-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI261-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI265-M_u2 INCP INCPB VSS VSS nch w=0.29u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI256 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI258-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI259-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI260-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI262-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI212-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI257-M_u3 d5 SLO VDD VDD pch w=0.2u l=0.06u
MI264-M_u3 SLO SLI VDD VDD pch w=0.52u l=0.06u
MI261-M_u3 SLO SLI VDD VDD pch w=0.52u l=0.06u
MI265-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQXD0 E SE CP SI D Q VDD VSS
MI79 net110 E net107 VSS nch w=0.15u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI244 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.15u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.15u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI249-M_u2 Q SLI VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI256-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI243 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.2u l=0.06u
MI77 VDD E net110 VDD pch w=0.2u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.2u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI249-M_u3 Q SLI VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI256-M_u3 d5 SLO VDD VDD pch w=0.15u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQXD1 E SE CP SI D Q VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI244 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI256-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI243 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI256-M_u3 d5 SLO VDD VDD pch w=0.15u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQXD2 E SE CP SI D Q VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI244 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI255-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI256-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI243 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI255-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI256-M_u3 d5 SLO VDD VDD pch w=0.15u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFQXD4 E SE CP SI D Q VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 d5 net108 net104 VSS nch w=0.195u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI244 SLI INCPB d5 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI255-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI268-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI265-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI259-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI260-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI271-M_u2 INCPB CP VSS VSS nch w=0.29u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI270-M_u2 INCP INCPB VSS VSS nch w=0.29u l=0.06u
MI267-M_u2 d5 SLO VSS VSS nch w=0.15u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 d5 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI243 SLI INCP d5 VDD pch w=0.15u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI255-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI268-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI265-M_u3 SLO SLI VDD VDD pch w=0.15u l=0.06u
MI259-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI260-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI271-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI270-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI267-M_u3 d5 SLO VDD VDD pch w=0.15u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFXD0 E SE CP SI D Q QN VDD VSS
MI79 net110 E net107 VSS nch w=0.15u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 net0109 net108 net104 VSS nch w=0.195u l=0.06u
MI251 SLI INCPB net096 VSS nch w=0.15u l=0.06u
MI250 net096 SLO VSS VSS nch w=0.15u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.15u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.15u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.195u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.15u l=0.06u
MI256-M_u2 QN SLO VSS VSS nch w=0.15u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MI257-M_u2 net0109 SLO VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 net0109 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI253 net0143 SLO VDD VDD pch w=0.15u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI254 SLI INCP net0143 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.2u l=0.06u
MI77 VDD E net110 VDD pch w=0.2u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.2u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.26u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.2u l=0.06u
MI256-M_u3 QN SLO VDD VDD pch w=0.2u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.19u l=0.06u
MI257-M_u3 net0109 SLO VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFXD1 E SE CP SI D Q QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 net0109 net108 net104 VSS nch w=0.195u l=0.06u
MI251 SLI INCPB net096 VSS nch w=0.15u l=0.06u
MI250 net096 SLO VSS VSS nch w=0.15u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI257-M_u2 net0109 SLO VSS VSS nch w=0.15u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI255-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.15u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 net0109 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI253 net0143 SLO VDD VDD pch w=0.15u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI254 SLI INCP net0143 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI257-M_u3 net0109 SLO VDD VDD pch w=0.2u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI255-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.2u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFXD2 E SE CP SI D Q QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 net0115 net108 net104 VSS nch w=0.195u l=0.06u
MI251 SLI INCPB net096 VSS nch w=0.15u l=0.06u
MI250 net096 SLO VSS VSS nch w=0.15u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI255-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI257-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI258-M_u2 net0115 SLO VSS VSS nch w=0.15u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI229-M_u2 INCPB CP VSS VSS nch w=0.195u l=0.06u
MI256-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI248-M_u2 SLO SLI VSS VSS nch w=0.195u l=0.06u
MU85-M_u2 INCP INCPB VSS VSS nch w=0.195u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 net0115 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI253 net0143 SLO VDD VDD pch w=0.15u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI254 SLI INCP net0143 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI255-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI257-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI258-M_u3 net0115 SLO VDD VDD pch w=0.2u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI229-M_u3 INCPB CP VDD VDD pch w=0.26u l=0.06u
MI256-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI248-M_u3 SLO SLI VDD VDD pch w=0.26u l=0.06u
MU85-M_u3 INCP INCPB VDD VDD pch w=0.26u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt SEDFXD4 E SE CP SI D Q QN VDD VSS
MI79 net110 E net107 VSS nch w=0.195u l=0.06u
MI135 net112 SI VSS VSS nch w=0.15u l=0.06u
MI238 net0164 INCPB VSS VSS nch w=0.2u l=0.06u
MI239 MLI d0 net0164 VSS nch w=0.2u l=0.06u
MI224 VSS E net95 VSS nch w=0.23u l=0.06u
MI222 net0116 net108 net104 VSS nch w=0.195u l=0.06u
MI251 SLI INCPB net096 VSS nch w=0.15u l=0.06u
MI250 net096 SLO VSS VSS nch w=0.15u l=0.06u
MI241 net0167 D d0 VSS nch w=0.23u l=0.06u
MI216 MLO INCP SLI VSS nch w=0.22u l=0.06u
MI119 net79 MLO VSS VSS nch w=0.15u l=0.06u
MI120 MLI INCP net79 VSS nch w=0.15u l=0.06u
MI128 net104 net147 d0 VSS nch w=0.195u l=0.06u
MI134 d0 SE net112 VSS nch w=0.15u l=0.06u
MI225 net95 net108 net0167 VSS nch w=0.23u l=0.06u
MI80 net107 net108 VSS VSS nch w=0.195u l=0.06u
MI255-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI227-M_u2 net147 E VSS VSS nch w=0.195u l=0.06u
MI257-M_u2 net0116 SLO VSS VSS nch w=0.15u l=0.06u
MI263-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI136-M_u2 net108 SE VSS VSS nch w=0.15u l=0.06u
MI264-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI265-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI259-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI266-M_u2 QN SLO VSS VSS nch w=0.39u l=0.06u
MI260-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI267-M_u2 INCPB CP VSS VSS nch w=0.31u l=0.06u
MI212-M_u2 Q SLI VSS VSS nch w=0.39u l=0.06u
MI269-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI258-M_u2 SLO SLI VSS VSS nch w=0.39u l=0.06u
MI268-M_u2 INCP INCPB VSS VSS nch w=0.25u l=0.06u
MI123-M_u2 MLO MLI VSS VSS nch w=0.35u l=0.06u
MI221 net0116 E net162 VDD pch w=0.26u l=0.06u
MI129 net162 SE d0 VDD pch w=0.26u l=0.06u
MI236 VDD INCP net0133 VDD pch w=0.27u l=0.06u
MI242 net0168 D d0 VDD pch w=0.38u l=0.06u
MI253 net0143 SLO VDD VDD pch w=0.15u l=0.06u
MI133 net177 net108 d0 VDD pch w=0.165u l=0.06u
MI226 VDD net110 net0168 VDD pch w=0.38u l=0.06u
MI254 SLI INCP net0143 VDD pch w=0.15u l=0.06u
MI210 MLO INCPB SLI VDD pch w=0.335u l=0.06u
MI235 net0133 d0 MLI VDD pch w=0.27u l=0.06u
MI102 net144 MLO VDD VDD pch w=0.15u l=0.06u
MI103 MLI INCPB net144 VDD pch w=0.15u l=0.06u
MI74 VDD net108 net110 VDD pch w=0.26u l=0.06u
MI77 VDD E net110 VDD pch w=0.26u l=0.06u
MI131 VDD SI net177 VDD pch w=0.165u l=0.06u
MI255-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI227-M_u3 net147 E VDD VDD pch w=0.25u l=0.06u
MI257-M_u3 net0116 SLO VDD VDD pch w=0.2u l=0.06u
MI263-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI136-M_u3 net108 SE VDD VDD pch w=0.2u l=0.06u
MI264-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI265-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI259-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI266-M_u3 QN SLO VDD VDD pch w=0.52u l=0.06u
MI260-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI267-M_u3 INCPB CP VDD VDD pch w=0.52u l=0.06u
MI212-M_u3 Q SLI VDD VDD pch w=0.52u l=0.06u
MI269-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
MI258-M_u3 SLO SLI VDD VDD pch w=0.5u l=0.06u
MI268-M_u3 INCP INCPB VDD VDD pch w=0.52u l=0.06u
MI123-M_u3 MLO MLI VDD VDD pch w=0.38u l=0.06u
.ends
.subckt TIEH Z VDD VSS
M_u2 net6 net6 VSS VSS nch w=0.41u l=0.06u
M_u1 Z net6 VDD VDD pch w=0.54u l=0.06u
.ends
.subckt TIEL ZN VDD VSS
M_u2 ZN net6 VSS VSS nch w=0.41u l=0.06u
M_u1 net6 net6 VDD VDD pch w=0.54u l=0.06u
.ends
.subckt XNR2D0 A1 A2 ZN VDD VSS
MI0-M_u3 net4 A1 net14 VSS nch w=0.195u l=0.06u
M_u7-M_u3 net6 net10 net14 VSS nch w=0.19u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.195u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 ZN net14 VSS VSS nch w=0.195u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.2u l=0.06u
MI0-M_u2 net4 net10 net14 VDD pch w=0.26u l=0.06u
M_u7-M_u2 net6 A1 net14 VDD pch w=0.26u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.26u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.21u l=0.06u
M_u4-M_u3 ZN net14 VDD VDD pch w=0.26u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR2D1 A1 A2 ZN VDD VSS
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u3 net4 A1 net14 VSS nch w=0.225u l=0.06u
MI0-M_u3 net6 net10 net14 VSS nch w=0.19u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
M_u6-M_u2 net4 net10 net14 VDD pch w=0.37u l=0.06u
MI0-M_u2 net6 A1 net14 VDD pch w=0.235u l=0.06u
.ends
.subckt XNR2D2 A1 A2 ZN VDD VSS
MI1-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 ZN net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u3 net4 A1 net14 VSS nch w=0.225u l=0.06u
MI0-M_u3 net6 net10 net14 VSS nch w=0.19u l=0.06u
MI1-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u3 ZN net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
M_u6-M_u2 net4 net10 net14 VDD pch w=0.37u l=0.06u
MI0-M_u2 net6 A1 net14 VDD pch w=0.235u l=0.06u
.ends
.subckt XNR2D4 A1 A2 ZN VDD VSS
MI6_0-M_u3 net27 A1 net35 VSS nch w=0.3u l=0.06u
MI6_1-M_u3 net27 A1 net35 VSS nch w=0.3u l=0.06u
MI0_0-M_u3 net26 net24 net35 VSS nch w=0.31u l=0.06u
MI0_1-M_u3 net26 net24 net35 VSS nch w=0.31u l=0.06u
MI12-M_u2 net26 net27 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 ZN net35 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 ZN net35 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 ZN net35 VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u2 net27 A2 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 net27 A2 VSS VSS nch w=0.39u l=0.06u
MI3_2-M_u2 net27 A2 VSS VSS nch w=0.39u l=0.06u
MI5-M_u2 ZN net35 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net24 A1 VSS VSS nch w=0.29u l=0.06u
MI6_0-M_u2 net27 net24 net35 VDD pch w=0.45u l=0.06u
MI6_1-M_u2 net27 net24 net35 VDD pch w=0.45u l=0.06u
MI0_0-M_u2 net26 A1 net35 VDD pch w=0.45u l=0.06u
MI0_1-M_u2 net26 A1 net35 VDD pch w=0.45u l=0.06u
MI12-M_u3 net26 net27 VDD VDD pch w=0.52u l=0.06u
MI9-M_u3 ZN net35 VDD VDD pch w=0.52u l=0.06u
MI8-M_u3 ZN net35 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 ZN net35 VDD VDD pch w=0.52u l=0.06u
MI3_0-M_u3 net27 A2 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 net27 A2 VDD VDD pch w=0.52u l=0.06u
MI3_2-M_u3 net27 A2 VDD VDD pch w=0.52u l=0.06u
MI5-M_u3 ZN net35 VDD VDD pch w=0.52u l=0.06u
MI13-M_u3 net24 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt XNR3D0 A1 A2 A3 ZN VDD VSS
MI8-M_u3 net11 A2 net17 VSS nch w=0.195u l=0.06u
MU11-M_u3 net5 net17 net21 VSS nch w=0.195u l=0.06u
MI5-M_u2 net5 A3 VSS VSS nch w=0.195u l=0.06u
MU22-M_u2 ZN net21 VSS VSS nch w=0.195u l=0.06u
M_u8-M_u2 net16 A2 VSS VSS nch w=0.195u l=0.06u
MI4-M_u2 net11 A1 VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net13 net17 VSS VSS nch w=0.195u l=0.06u
MI2-MU3 net17 net16 XI2-net16 VSS nch w=0.195u l=0.06u
MI2-MU4 XI2-net16 net11 VSS VSS nch w=0.195u l=0.06u
MU21-MU3 net21 net13 XU21-net16 VSS nch w=0.195u l=0.06u
MU21-MU4 XU21-net16 net5 VSS VSS nch w=0.195u l=0.06u
MI8-M_u2 net11 net16 net17 VDD pch w=0.26u l=0.06u
MU11-M_u2 net5 net13 net21 VDD pch w=0.26u l=0.06u
MI5-M_u3 net5 A3 VDD VDD pch w=0.26u l=0.06u
MU22-M_u3 ZN net21 VDD VDD pch w=0.26u l=0.06u
M_u8-M_u3 net16 A2 VDD VDD pch w=0.26u l=0.06u
MI4-M_u3 net11 A1 VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net13 net17 VDD VDD pch w=0.26u l=0.06u
MI2-MU2 net17 A2 XI2-net6 VDD pch w=0.26u l=0.06u
MI2-MU1 XI2-net6 net11 VDD VDD pch w=0.26u l=0.06u
MU21-MU2 net21 net17 XU21-net6 VDD pch w=0.26u l=0.06u
MU21-MU1 XU21-net6 net5 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR3D1 A1 A2 A3 ZN VDD VSS
M_u6-M_u3 net11 A2 net17 VSS nch w=0.195u l=0.06u
MU11-M_u3 net5 net17 net21 VSS nch w=0.28u l=0.06u
MI1-M_u2 net5 A3 VSS VSS nch w=0.39u l=0.06u
MU22-M_u2 ZN net21 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net16 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net11 A1 VSS VSS nch w=0.39u l=0.06u
MU12-M_u2 net13 net17 VSS VSS nch w=0.195u l=0.06u
MI0-MU3 net17 net16 XI0-net16 VSS nch w=0.21u l=0.06u
MI0-MU4 XI0-net16 net11 VSS VSS nch w=0.21u l=0.06u
MI3-MU3 net21 net13 XI3-net16 VSS nch w=0.23u l=0.06u
MI3-MU4 XI3-net16 net5 VSS VSS nch w=0.23u l=0.06u
M_u6-M_u2 net11 net16 net17 VDD pch w=0.26u l=0.06u
MU11-M_u2 net5 net13 net21 VDD pch w=0.45u l=0.06u
MI1-M_u3 net5 A3 VDD VDD pch w=0.52u l=0.06u
MU22-M_u3 ZN net21 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net16 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u3 net11 A1 VDD VDD pch w=0.52u l=0.06u
MU12-M_u3 net13 net17 VDD VDD pch w=0.26u l=0.06u
MI0-MU2 net17 A2 XI0-net6 VDD pch w=0.36u l=0.06u
MI0-MU1 XI0-net6 net11 VDD VDD pch w=0.34u l=0.06u
MI3-MU2 net21 net17 XI3-net6 VDD pch w=0.32u l=0.06u
MI3-MU1 XI3-net6 net5 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR3D2 A1 A2 A3 ZN VDD VSS
MI8-M_u2 net42 net11 VSS VSS nch w=0.19u l=0.06u
MI5-M_u2 net44 net5 VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net5 A3 VSS VSS nch w=0.39u l=0.06u
MU22_0-M_u2 ZN net36 VSS VSS nch w=0.39u l=0.06u
MU22_1-M_u2 ZN net36 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net16 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net11 A1 VSS VSS nch w=0.39u l=0.06u
MU12-M_u2 net54 net32 VSS VSS nch w=0.195u l=0.06u
MI3-M_u3 net42 net16 net32 VSS nch w=0.19u l=0.06u
M_u6-M_u3 net11 A2 net32 VSS nch w=0.195u l=0.06u
MU11-M_u3 net5 net32 net36 VSS nch w=0.3u l=0.06u
MI4-M_u3 net44 net54 net36 VSS nch w=0.32u l=0.06u
MI8-M_u3 net42 net11 VDD VDD pch w=0.26u l=0.06u
MI5-M_u3 net44 net5 VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net5 A3 VDD VDD pch w=0.52u l=0.06u
MU22_0-M_u3 ZN net36 VDD VDD pch w=0.52u l=0.06u
MU22_1-M_u3 ZN net36 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net16 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u3 net11 A1 VDD VDD pch w=0.52u l=0.06u
MU12-M_u3 net54 net32 VDD VDD pch w=0.26u l=0.06u
MI3-M_u2 net42 A2 net32 VDD pch w=0.235u l=0.06u
M_u6-M_u2 net11 net16 net32 VDD pch w=0.26u l=0.06u
MU11-M_u2 net5 net54 net36 VDD pch w=0.45u l=0.06u
MI4-M_u2 net44 net32 net36 VDD pch w=0.45u l=0.06u
.ends
.subckt XNR3D4 A1 A2 A3 ZN VDD VSS
M_u6-M_u3 net27 A2 net26 VSS nch w=0.195u l=0.06u
MI2-M_u3 net39 net25 net26 VSS nch w=0.19u l=0.06u
MU11-M_u3 p1 net26 p0 VSS nch w=0.25u l=0.06u
MI5-M_u3 net045 net40 p0 VSS nch w=0.32u l=0.06u
MI7-M_u2 net39 net27 VSS VSS nch w=0.19u l=0.06u
MI8-M_u2 net045 p1 VSS VSS nch w=0.65u l=0.06u
MI1_0-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MU22_0-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU22_1-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU22_2-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU22_3-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net25 A2 VSS VSS nch w=0.195u l=0.06u
M_u2_0-M_u2 net27 A1 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 net27 A1 VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 net27 A1 VSS VSS nch w=0.39u l=0.06u
MU12-M_u2 net40 net26 VSS VSS nch w=0.39u l=0.06u
M_u6-M_u2 net27 net25 net26 VDD pch w=0.265u l=0.06u
MI2-M_u2 net39 A2 net26 VDD pch w=0.265u l=0.06u
MU11-M_u2 p1 net40 p0 VDD pch w=0.45u l=0.06u
MI5-M_u2 net045 net26 p0 VDD pch w=0.43u l=0.06u
MI7-M_u3 net39 net27 VDD VDD pch w=0.34u l=0.06u
MI8-M_u3 net045 p1 VDD VDD pch w=0.835u l=0.06u
MI1_0-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MU22_0-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU22_1-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU22_2-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU22_3-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net25 A2 VDD VDD pch w=0.26u l=0.06u
M_u2_0-M_u3 net27 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 net27 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 net27 A1 VDD VDD pch w=0.52u l=0.06u
MU12-M_u3 net40 net26 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt XNR4D0 A1 A2 A3 A4 ZN VDD VSS
MI21 net24 A1 net046 VSS nch w=0.195u l=0.06u
MI22 net046 net32 VSS VSS nch w=0.195u l=0.06u
MI15-M_u3 net28 net20 net64 VSS nch w=0.195u l=0.06u
MI8-M_u3 net24 net30 net32 VSS nch w=0.195u l=0.06u
MI17-M_u3 net28 net40 net24 VSS nch w=0.195u l=0.06u
MI11-M_u3 net20 A4 net108 VSS nch w=0.195u l=0.06u
MI9-M_u3 net20 net106 net104 VSS nch w=0.195u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI18-M_u2 net32 A2 VSS VSS nch w=0.195u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20-M_u2 ZN net28 VSS VSS nch w=0.195u l=0.06u
MI19-M_u2 net104 A3 VSS VSS nch w=0.195u l=0.06u
MI16-M_u2 net64 net24 VSS VSS nch w=0.195u l=0.06u
MU14-M_u2 net40 net20 VSS VSS nch w=0.195u l=0.06u
MI20 net24 net30 net045 VDD pch w=0.26u l=0.06u
M_u2 net045 net32 VDD VDD pch w=0.26u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI8-M_u2 net24 A1 net32 VDD pch w=0.26u l=0.06u
MI17-M_u2 net28 net20 net24 VDD pch w=0.26u l=0.06u
MI11-M_u2 net20 net106 net108 VDD pch w=0.26u l=0.06u
MI9-M_u2 net20 A4 net104 VDD pch w=0.26u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI18-M_u3 net32 A2 VDD VDD pch w=0.26u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20-M_u3 ZN net28 VDD VDD pch w=0.26u l=0.06u
MI19-M_u3 net104 A3 VDD VDD pch w=0.26u l=0.06u
MI16-M_u3 net64 net24 VDD VDD pch w=0.26u l=0.06u
MU14-M_u3 net40 net20 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR4D1 A1 A2 A3 A4 ZN VDD VSS
MI21 net24 A1 net043 VSS nch w=0.195u l=0.06u
MI22 net043 net32 VSS VSS nch w=0.195u l=0.06u
MI15-M_u3 net28 net20 net64 VSS nch w=0.195u l=0.06u
MI8-M_u3 net24 net30 net32 VSS nch w=0.195u l=0.06u
MI17-M_u3 net28 net40 net24 VSS nch w=0.195u l=0.06u
MI11-M_u3 net20 A4 net108 VSS nch w=0.195u l=0.06u
MI9-M_u3 net20 net106 net104 VSS nch w=0.195u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net104 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net32 A2 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net64 net24 VSS VSS nch w=0.195u l=0.06u
MU14-M_u2 net40 net20 VSS VSS nch w=0.195u l=0.06u
M_u2 net049 net32 VDD VDD pch w=0.26u l=0.06u
MI20 net24 net30 net049 VDD pch w=0.26u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI8-M_u2 net24 A1 net32 VDD pch w=0.26u l=0.06u
MI17-M_u2 net28 net20 net24 VDD pch w=0.26u l=0.06u
MI11-M_u2 net20 net106 net108 VDD pch w=0.26u l=0.06u
MI9-M_u2 net20 A4 net104 VDD pch w=0.26u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net104 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net32 A2 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 net64 net24 VDD VDD pch w=0.26u l=0.06u
MU14-M_u3 net40 net20 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR4D2 A1 A2 A3 A4 ZN VDD VSS
MI15-M_u3 net28 net20 net64 VSS nch w=0.195u l=0.06u
MI8-M_u3 net24 net30 net32 VSS nch w=0.195u l=0.06u
MI6-M_u3 net24 A1 net56 VSS nch w=0.195u l=0.06u
MI17-M_u3 net28 net40 net24 VSS nch w=0.195u l=0.06u
MI11-M_u3 net20 A4 net108 VSS nch w=0.195u l=0.06u
MI9-M_u3 net20 net106 net104 VSS nch w=0.195u l=0.06u
MI19-M_u2 net56 net32 VSS VSS nch w=0.195u l=0.06u
MI21-M_u2 net64 net24 VSS VSS nch w=0.21u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net104 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20_0-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MU20_1-M_u2 ZN net28 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net32 A2 VSS VSS nch w=0.39u l=0.06u
MU14-M_u2 net40 net20 VSS VSS nch w=0.195u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI8-M_u2 net24 A1 net32 VDD pch w=0.26u l=0.06u
MI6-M_u2 net24 net30 net56 VDD pch w=0.26u l=0.06u
MI17-M_u2 net28 net20 net24 VDD pch w=0.26u l=0.06u
MI11-M_u2 net20 net106 net108 VDD pch w=0.26u l=0.06u
MI9-M_u2 net20 A4 net104 VDD pch w=0.26u l=0.06u
MI19-M_u3 net56 net32 VDD VDD pch w=0.26u l=0.06u
MI21-M_u3 net64 net24 VDD VDD pch w=0.34u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net104 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20_0-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MU20_1-M_u3 ZN net28 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net32 A2 VDD VDD pch w=0.52u l=0.06u
MU14-M_u3 net40 net20 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XNR4D4 A1 A2 A3 A4 ZN VDD VSS
MI15-M_u3 p0 net63 net78 VSS nch w=0.195u l=0.06u
MI8-M_u3 net79 net70 net67 VSS nch w=0.195u l=0.06u
MI6-M_u3 net79 A1 net66 VSS nch w=0.195u l=0.06u
MI17-M_u3 p0 net80 net79 VSS nch w=0.195u l=0.06u
MI11-M_u3 net63 A4 net72 VSS nch w=0.195u l=0.06u
MI9-M_u3 net63 net64 net68 VSS nch w=0.195u l=0.06u
MI13-M_u2 net64 A4 VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net66 net67 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net68 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net70 A1 VSS VSS nch w=0.195u l=0.06u
MI18-M_u2 net72 net68 VSS VSS nch w=0.19u l=0.06u
MU20_0-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU20_1-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU20_2-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MU20_3-M_u2 ZN p0 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net67 A2 VSS VSS nch w=0.39u l=0.06u
MI16-M_u2 net78 net79 VSS VSS nch w=0.21u l=0.06u
MU14-M_u2 net80 net63 VSS VSS nch w=0.195u l=0.06u
MI15-M_u2 p0 net80 net78 VDD pch w=0.26u l=0.06u
MI8-M_u2 net79 A1 net67 VDD pch w=0.26u l=0.06u
MI6-M_u2 net79 net70 net66 VDD pch w=0.26u l=0.06u
MI17-M_u2 p0 net63 net79 VDD pch w=0.26u l=0.06u
MI11-M_u2 net63 net64 net72 VDD pch w=0.26u l=0.06u
MI9-M_u2 net63 A4 net68 VDD pch w=0.26u l=0.06u
MI13-M_u3 net64 A4 VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net66 net67 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net68 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net70 A1 VDD VDD pch w=0.26u l=0.06u
MI18-M_u3 net72 net68 VDD VDD pch w=0.21u l=0.06u
MU20_0-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU20_1-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU20_2-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MU20_3-M_u3 ZN p0 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net67 A2 VDD VDD pch w=0.52u l=0.06u
MI16-M_u3 net78 net79 VDD VDD pch w=0.34u l=0.06u
MU14-M_u3 net80 net63 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR2D0 A1 A2 Z VDD VSS
M_u6-M_u3 net4 net10 net14 VSS nch w=0.195u l=0.06u
MI5-M_u3 net6 A1 net14 VSS nch w=0.195u l=0.06u
MI1-M_u2 net4 A2 VSS VSS nch w=0.195u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 Z net14 VSS VSS nch w=0.195u l=0.06u
MI4-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.26u l=0.06u
MI5-M_u2 net6 net10 net14 VDD pch w=0.26u l=0.06u
MI1-M_u3 net4 A2 VDD VDD pch w=0.26u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.21u l=0.06u
M_u4-M_u3 Z net14 VDD VDD pch w=0.26u l=0.06u
MI4-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR2D1 A1 A2 Z VDD VSS
M_u6-M_u3 net4 net10 net14 VSS nch w=0.32u l=0.06u
MI1-M_u3 net6 A1 net14 VSS nch w=0.31u l=0.06u
M_u2-M_u2 net4 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net4 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 Z net14 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net10 A1 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net4 A1 net14 VDD pch w=0.34u l=0.06u
MI1-M_u2 net6 net10 net14 VDD pch w=0.31u l=0.06u
M_u2-M_u3 net4 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net4 VDD VDD pch w=0.21u l=0.06u
M_u4-M_u3 Z net14 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net10 A1 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR2D2 A1 A2 Z VDD VSS
MI2-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u2 net23 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net21 net23 VSS VSS nch w=0.19u l=0.06u
M_u4-M_u2 Z net27 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net17 A1 VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 net21 A1 net27 VSS nch w=0.31u l=0.06u
M_u6-M_u3 net23 net17 net27 VSS nch w=0.32u l=0.06u
MI2-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u2-M_u3 net23 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net21 net23 VDD VDD pch w=0.26u l=0.06u
M_u4-M_u3 Z net27 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net17 A1 VDD VDD pch w=0.26u l=0.06u
MI1-M_u2 net21 net17 net27 VDD pch w=0.31u l=0.06u
M_u6-M_u2 net23 A1 net27 VDD pch w=0.34u l=0.06u
.ends
.subckt XOR2D4 A1 A2 Z VDD VSS
MI3_0-M_u3 net026 net29 p0 VSS nch w=0.3u l=0.06u
MI3_1-M_u3 net026 net29 p0 VSS nch w=0.3u l=0.06u
MI4_0-M_u3 net6 A1 p0 VSS nch w=0.31u l=0.06u
MI4_1-M_u3 net6 A1 p0 VSS nch w=0.31u l=0.06u
M_u2_0-M_u2 net026 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 net026 A2 VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 net026 A2 VSS VSS nch w=0.39u l=0.06u
M_u5-M_u2 net6 net026 VSS VSS nch w=0.39u l=0.06u
M_u4_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u4_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net29 A1 VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u2 net026 A1 p0 VDD pch w=0.45u l=0.06u
MI3_1-M_u2 net026 A1 p0 VDD pch w=0.45u l=0.06u
MI4_0-M_u2 net6 net29 p0 VDD pch w=0.45u l=0.06u
MI4_1-M_u2 net6 net29 p0 VDD pch w=0.45u l=0.06u
M_u2_0-M_u3 net026 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 net026 A2 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 net026 A2 VDD VDD pch w=0.52u l=0.06u
M_u5-M_u3 net6 net026 VDD VDD pch w=0.52u l=0.06u
M_u4_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u4_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net29 A1 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt XOR3D0 A1 A2 A3 Z VDD VSS
M_u6-M_u3 net19 net17 net25 VSS nch w=0.195u l=0.06u
MU18-M_u3 net13 net25 net29 VSS nch w=0.195u l=0.06u
MI1-M_u2 Z net29 VSS VSS nch w=0.195u l=0.06u
MI3-M_u2 net13 A3 VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net17 A2 VSS VSS nch w=0.195u l=0.06u
MI2-M_u2 net19 A1 VSS VSS nch w=0.195u l=0.06u
MI6-M_u2 net21 net25 VSS VSS nch w=0.195u l=0.06u
MU33-MU3 net29 net21 XU33-net16 VSS nch w=0.195u l=0.06u
MU33-MU4 XU33-net16 net13 VSS VSS nch w=0.195u l=0.06u
MI5-MU3 net25 A2 XI5-net16 VSS nch w=0.195u l=0.06u
MI5-MU4 XI5-net16 net19 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net19 A2 net25 VDD pch w=0.26u l=0.06u
MU18-M_u2 net13 net21 net29 VDD pch w=0.26u l=0.06u
MI1-M_u3 Z net29 VDD VDD pch w=0.26u l=0.06u
MI3-M_u3 net13 A3 VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net17 A2 VDD VDD pch w=0.26u l=0.06u
MI2-M_u3 net19 A1 VDD VDD pch w=0.26u l=0.06u
MI6-M_u3 net21 net25 VDD VDD pch w=0.26u l=0.06u
MU33-MU2 net29 net25 XU33-net6 VDD pch w=0.26u l=0.06u
MU33-MU1 XU33-net6 net13 VDD VDD pch w=0.26u l=0.06u
MI5-MU2 net25 net17 XI5-net6 VDD pch w=0.26u l=0.06u
MI5-MU1 XI5-net6 net19 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR3D1 A1 A2 A3 Z VDD VSS
M_u6-M_u3 net19 net17 net25 VSS nch w=0.195u l=0.06u
MU18-M_u3 net13 net25 net29 VSS nch w=0.28u l=0.06u
MU13-M_u2 net13 A3 VSS VSS nch w=0.39u l=0.06u
MU14-M_u2 Z net29 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net17 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net19 A1 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 net21 net25 VSS VSS nch w=0.195u l=0.06u
MU33-MU3 net29 net21 XU33-net16 VSS nch w=0.23u l=0.06u
MU33-MU4 XU33-net16 net13 VSS VSS nch w=0.23u l=0.06u
MI0-MU3 net25 A2 XI0-net16 VSS nch w=0.195u l=0.06u
MI0-MU4 XI0-net16 net19 VSS VSS nch w=0.195u l=0.06u
M_u6-M_u2 net19 A2 net25 VDD pch w=0.26u l=0.06u
MU18-M_u2 net13 net21 net29 VDD pch w=0.45u l=0.06u
MU13-M_u3 net13 A3 VDD VDD pch w=0.52u l=0.06u
MU14-M_u3 Z net29 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net17 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u3 net19 A1 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 net21 net25 VDD VDD pch w=0.26u l=0.06u
MU33-MU2 net29 net25 XU33-net6 VDD pch w=0.32u l=0.06u
MU33-MU1 XU33-net6 net13 VDD VDD pch w=0.26u l=0.06u
MI0-MU2 net25 net17 XI0-net6 VDD pch w=0.26u l=0.06u
MI0-MU1 XI0-net6 net19 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR3D2 A1 A2 A3 Z VDD VSS
MI6-M_u2 net13 A3 VSS VSS nch w=0.39u l=0.06u
MI8-M_u2 net44 net19 VSS VSS nch w=0.19u l=0.06u
MI9-M_u2 net42 net13 VSS VSS nch w=0.15u l=0.06u
MU14_0-M_u2 Z net32 VSS VSS nch w=0.39u l=0.06u
MU14_1-M_u2 Z net32 VSS VSS nch w=0.39u l=0.06u
MI7-M_u2 net17 A2 VSS VSS nch w=0.195u l=0.06u
M_u2-M_u2 net19 A1 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 net21 net25 VSS VSS nch w=0.195u l=0.06u
MI3-M_u3 net42 net21 net32 VSS nch w=0.19u l=0.06u
M_u6-M_u3 net19 net17 net25 VSS nch w=0.195u l=0.06u
MI1-M_u3 net44 A2 net25 VSS nch w=0.195u l=0.06u
MU18-M_u3 net13 net25 net32 VSS nch w=0.27u l=0.06u
MI6-M_u3 net13 A3 VDD VDD pch w=0.52u l=0.06u
MI8-M_u3 net44 net19 VDD VDD pch w=0.21u l=0.06u
MI9-M_u3 net42 net13 VDD VDD pch w=0.24u l=0.06u
MU14_0-M_u3 Z net32 VDD VDD pch w=0.52u l=0.06u
MU14_1-M_u3 Z net32 VDD VDD pch w=0.52u l=0.06u
MI7-M_u3 net17 A2 VDD VDD pch w=0.26u l=0.06u
M_u2-M_u3 net19 A1 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 net21 net25 VDD VDD pch w=0.24u l=0.06u
MI3-M_u2 net42 net25 net32 VDD pch w=0.33u l=0.06u
M_u6-M_u2 net19 A2 net25 VDD pch w=0.26u l=0.06u
MI1-M_u2 net44 net17 net25 VDD pch w=0.26u l=0.06u
MU18-M_u2 net13 net21 net32 VDD pch w=0.45u l=0.06u
.ends
.subckt XOR3D4 A1 A2 A3 Z VDD VSS
MI9-M_u3 net031 net21 p0 VSS nch w=0.32u l=0.06u
M_u6-M_u3 net29 net17 net28 VSS nch w=0.195u l=0.06u
MI1-M_u3 net28 A2 net39 VSS nch w=0.195u l=0.06u
MU18-M_u3 p1 net28 p0 VSS nch w=0.25u l=0.06u
MI7-M_u2 net39 net29 VSS VSS nch w=0.19u l=0.06u
MI8_0-M_u2 net031 p1 VSS VSS nch w=0.39u l=0.06u
MI8_1-M_u2 net031 p1 VSS VSS nch w=0.39u l=0.06u
MU13_0-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MU13_1-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MU13_2-M_u2 p1 A3 VSS VSS nch w=0.39u l=0.06u
MU14_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU14_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU14_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU14_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI11-M_u2 net17 A2 VSS VSS nch w=0.195u l=0.06u
M_u2_0-M_u2 net29 A1 VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 net29 A1 VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 net29 A1 VSS VSS nch w=0.39u l=0.06u
M_u4-M_u2 net21 net28 VSS VSS nch w=0.39u l=0.06u
MI9-M_u2 net031 net28 p0 VDD pch w=0.45u l=0.06u
M_u6-M_u2 net29 A2 net28 VDD pch w=0.26u l=0.06u
MI1-M_u2 net28 net17 net39 VDD pch w=0.26u l=0.06u
MU18-M_u2 p1 net21 p0 VDD pch w=0.45u l=0.06u
MI7-M_u3 net39 net29 VDD VDD pch w=0.21u l=0.06u
MI8_0-M_u3 net031 p1 VDD VDD pch w=0.43u l=0.06u
MI8_1-M_u3 net031 p1 VDD VDD pch w=0.43u l=0.06u
MU13_0-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MU13_1-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MU13_2-M_u3 p1 A3 VDD VDD pch w=0.52u l=0.06u
MU14_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU14_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU14_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU14_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI11-M_u3 net17 A2 VDD VDD pch w=0.26u l=0.06u
M_u2_0-M_u3 net29 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 net29 A1 VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 net29 A1 VDD VDD pch w=0.52u l=0.06u
M_u4-M_u3 net21 net28 VDD VDD pch w=0.54u l=0.06u
.ends
.subckt XOR4D0 A1 A2 A3 A4 Z VDD VSS
MI21 net24 A1 net050 VSS nch w=0.195u l=0.06u
MI22 net050 net32 VSS VSS nch w=0.195u l=0.06u
MI15-M_u3 net28 net20 net64 VSS nch w=0.195u l=0.06u
MI8-M_u3 net24 net30 net32 VSS nch w=0.195u l=0.06u
MI17-M_u3 net28 net40 net24 VSS nch w=0.195u l=0.06u
MI11-M_u3 net40 A4 net108 VSS nch w=0.195u l=0.06u
MI9-M_u3 net40 net106 net104 VSS nch w=0.195u l=0.06u
MI19-M_u2 net20 net40 VSS VSS nch w=0.195u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net104 A3 VSS VSS nch w=0.195u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20-M_u2 Z net28 VSS VSS nch w=0.195u l=0.06u
MI1-M_u2 net32 A2 VSS VSS nch w=0.195u l=0.06u
MI16-M_u2 net64 net24 VSS VSS nch w=0.195u l=0.06u
MI20 net24 net30 net045 VDD pch w=0.26u l=0.06u
M_u2 net045 net32 VDD VDD pch w=0.26u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI8-M_u2 net24 A1 net32 VDD pch w=0.26u l=0.06u
MI17-M_u2 net28 net20 net24 VDD pch w=0.26u l=0.06u
MI11-M_u2 net40 net106 net108 VDD pch w=0.26u l=0.06u
MI9-M_u2 net40 A4 net104 VDD pch w=0.26u l=0.06u
MI19-M_u3 net20 net40 VDD VDD pch w=0.26u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net104 A3 VDD VDD pch w=0.26u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20-M_u3 Z net28 VDD VDD pch w=0.26u l=0.06u
MI1-M_u3 net32 A2 VDD VDD pch w=0.26u l=0.06u
MI16-M_u3 net64 net24 VDD VDD pch w=0.26u l=0.06u
.ends
.subckt XOR4D1 A1 A2 A3 A4 Z VDD VSS
MI21 net24 A1 net048 VSS nch w=0.195u l=0.06u
MI29 net048 net32 VSS VSS nch w=0.195u l=0.06u
MI15-M_u3 net28 net20 net64 VSS nch w=0.21u l=0.06u
MI26-M_u3 net24 net30 net32 VSS nch w=0.32u l=0.06u
MI28-M_u3 net40 net106 net104 VSS nch w=0.32u l=0.06u
MI27-M_u3 net40 A4 net108 VSS nch w=0.29u l=0.06u
MI24-M_u3 net28 net40 net24 VSS nch w=0.295u l=0.06u
MI22-M_u2 net64 net24 VSS VSS nch w=0.21u l=0.06u
MI23-M_u2 net20 net40 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net104 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net32 A2 VSS VSS nch w=0.39u l=0.06u
MI20 net24 net30 net043 VDD pch w=0.26u l=0.06u
M_u2 net043 net32 VDD VDD pch w=0.26u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI26-M_u2 net24 A1 net32 VDD pch w=0.415u l=0.06u
MI28-M_u2 net40 A4 net104 VDD pch w=0.32u l=0.06u
MI27-M_u2 net40 net106 net108 VDD pch w=0.32u l=0.06u
MI24-M_u2 net28 net20 net24 VDD pch w=0.45u l=0.06u
MI22-M_u3 net64 net24 VDD VDD pch w=0.34u l=0.06u
MI23-M_u3 net20 net40 VDD VDD pch w=0.37u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net104 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net32 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt XOR4D2 A1 A2 A3 A4 Z VDD VSS
MI15-M_u3 net28 net20 net64 VSS nch w=0.21u l=0.06u
MI26-M_u3 net24 net30 net32 VSS nch w=0.32u l=0.06u
MI28-M_u3 net40 net106 net104 VSS nch w=0.32u l=0.06u
MI27-M_u3 net40 A4 net108 VSS nch w=0.29u l=0.06u
MI24-M_u3 net28 net40 net24 VSS nch w=0.295u l=0.06u
MI25-M_u3 net24 A1 net56 VSS nch w=0.195u l=0.06u
MI22-M_u2 net64 net24 VSS VSS nch w=0.21u l=0.06u
MI29-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 net20 net40 VSS VSS nch w=0.39u l=0.06u
MI13-M_u2 net106 A4 VSS VSS nch w=0.195u l=0.06u
MI7-M_u2 net56 net32 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net104 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net30 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net108 net104 VSS VSS nch w=0.19u l=0.06u
MU20-M_u2 Z net28 VSS VSS nch w=0.39u l=0.06u
MI1-M_u2 net32 A2 VSS VSS nch w=0.39u l=0.06u
MI15-M_u2 net28 net40 net64 VDD pch w=0.26u l=0.06u
MI26-M_u2 net24 A1 net32 VDD pch w=0.415u l=0.06u
MI28-M_u2 net40 A4 net104 VDD pch w=0.32u l=0.06u
MI27-M_u2 net40 net106 net108 VDD pch w=0.32u l=0.06u
MI24-M_u2 net28 net20 net24 VDD pch w=0.45u l=0.06u
MI25-M_u2 net24 net30 net56 VDD pch w=0.26u l=0.06u
MI22-M_u3 net64 net24 VDD VDD pch w=0.34u l=0.06u
MI29-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI23-M_u3 net20 net40 VDD VDD pch w=0.37u l=0.06u
MI13-M_u3 net106 A4 VDD VDD pch w=0.26u l=0.06u
MI7-M_u3 net56 net32 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net104 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net30 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net108 net104 VDD VDD pch w=0.21u l=0.06u
MU20-M_u3 Z net28 VDD VDD pch w=0.52u l=0.06u
MI1-M_u3 net32 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt XOR4D4 A1 A2 A3 A4 Z VDD VSS
MI23-M_u3 net64 A1 net47 VSS nch w=0.275u l=0.06u
MI35-M_u3 net81 net66 p0 VSS nch w=0.32u l=0.06u
MI36-M_u3 net47 net63 p0 VSS nch w=0.195u l=0.06u
MI33-M_u3 net74 A4 net63 VSS nch w=0.29u l=0.06u
MI34-M_u3 net70 net68 net63 VSS nch w=0.32u l=0.06u
MI32-M_u3 net65 net72 net47 VSS nch w=0.32u l=0.06u
MI27-M_u2 net64 net65 VSS VSS nch w=0.21u l=0.06u
MI31_0-M_u2 net81 net47 VSS VSS nch w=0.39u l=0.06u
MI31_1-M_u2 net81 net47 VSS VSS nch w=0.39u l=0.06u
MI26-M_u2 net66 net63 VSS VSS nch w=0.195u l=0.06u
MI13-M_u2 net68 A4 VSS VSS nch w=0.195u l=0.06u
MI14-M_u2 net70 A3 VSS VSS nch w=0.39u l=0.06u
M_u8-M_u2 net72 A1 VSS VSS nch w=0.195u l=0.06u
MI12-M_u2 net74 net70 VSS VSS nch w=0.19u l=0.06u
MU20_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU20_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU20_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MU20_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u2 net65 A2 VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u2 net65 A2 VSS VSS nch w=0.39u l=0.06u
MI23-M_u2 net64 net72 net47 VDD pch w=0.26u l=0.06u
MI35-M_u2 net81 net63 p0 VDD pch w=0.42u l=0.06u
MI36-M_u2 net47 net66 p0 VDD pch w=0.24u l=0.06u
MI33-M_u2 net74 net68 net63 VDD pch w=0.32u l=0.06u
MI34-M_u2 net70 A4 net63 VDD pch w=0.32u l=0.06u
MI32-M_u2 net65 A1 net47 VDD pch w=0.335u l=0.06u
MI27-M_u3 net64 net65 VDD VDD pch w=0.34u l=0.06u
MI31_0-M_u3 net81 net47 VDD VDD pch w=0.52u l=0.06u
MI31_1-M_u3 net81 net47 VDD VDD pch w=0.52u l=0.06u
MI26-M_u3 net66 net63 VDD VDD pch w=0.26u l=0.06u
MI13-M_u3 net68 A4 VDD VDD pch w=0.26u l=0.06u
MI14-M_u3 net70 A3 VDD VDD pch w=0.52u l=0.06u
M_u8-M_u3 net72 A1 VDD VDD pch w=0.26u l=0.06u
MI12-M_u3 net74 net70 VDD VDD pch w=0.21u l=0.06u
MU20_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU20_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU20_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MU20_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u3 net65 A2 VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u3 net65 A2 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ISOHID1 ISO I Z VDD VSS
MI3-M_u2 Z net15 VSS VSS nch w=0.39u l=0.06u
MI1-M_u4 net15 I VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net15 ISO VSS VSS nch w=0.39u l=0.06u
MI3-M_u3 Z net15 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 XI1-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net15 I XI1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt ISOHID2 ISO I Z VDD VSS
MI3_0-M_u2 Z net11 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 Z net11 VSS VSS nch w=0.39u l=0.06u
MI1-M_u4 net11 I VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net11 ISO VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u3 Z net11 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 Z net11 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 XI1-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net11 I XI1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt ISOHID4 ISO I Z VDD VSS
MI3_0-M_u2 Z net20 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 Z net20 VSS VSS nch w=0.39u l=0.06u
MI3_2-M_u2 Z net20 VSS VSS nch w=0.39u l=0.06u
MI3_3-M_u2 Z net20 VSS VSS nch w=0.39u l=0.06u
MI1-M_u4 net20 I VSS VSS nch w=0.39u l=0.06u
MI1-M_u3 net20 ISO VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u3 Z net20 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 Z net20 VDD VDD pch w=0.52u l=0.06u
MI3_2-M_u3 Z net20 VDD VDD pch w=0.52u l=0.06u
MI3_3-M_u3 Z net20 VDD VDD pch w=0.52u l=0.06u
MI1-M_u1 XI1-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1-M_u2 net20 I XI1-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt ISOHID8 ISO I Z VDD VSS
MI3_0-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_1-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_2-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_3-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_4-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_5-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_6-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI3_7-M_u2 Z P0 VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u4 P0 I VSS VSS nch w=0.39u l=0.06u
MI1_0-M_u3 P0 ISO VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u4 P0 I VSS VSS nch w=0.39u l=0.06u
MI1_1-M_u3 P0 ISO VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u4 P0 I VSS VSS nch w=0.39u l=0.06u
MI1_2-M_u3 P0 ISO VSS VSS nch w=0.39u l=0.06u
MI3_0-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_1-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_2-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_3-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_4-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_5-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_6-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI3_7-M_u3 Z P0 VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u1 XI1_0-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1_0-M_u2 P0 I XI1_0-net8 VDD pch w=0.52u l=0.06u
MI1_1-M_u1 XI1_1-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1_1-M_u2 P0 I XI1_1-net8 VDD pch w=0.52u l=0.06u
MI1_2-M_u1 XI1_2-net8 ISO VDD VDD pch w=0.52u l=0.06u
MI1_2-M_u2 P0 I XI1_2-net8 VDD pch w=0.52u l=0.06u
.ends
.subckt ISOLOD1 ISO I Z VDD VSS
MI3-M_u3 Z net025 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net13 ISO VDD VDD pch w=0.26u l=0.06u
M_u16 VDD net13 net025 VDD pch w=0.52u l=0.06u
MI11 VDD I net025 VDD pch w=0.52u l=0.06u
MI3-M_u2 Z net025 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net13 ISO VSS VSS nch w=0.195u l=0.06u
MI13 net16 net13 VSS VSS nch w=0.39u l=0.06u
MI12 net025 I net16 VSS nch w=0.39u l=0.06u
.ends
.subckt ISOLOD2 ISO I Z VDD VSS
MI4 net22 net017 VSS VSS nch w=0.39u l=0.06u
MI12 net037 I net22 VSS nch w=0.39u l=0.06u
MI13-M_u2 net017 ISO VSS VSS nch w=0.195u l=0.06u
M_u3-M_u2 Z net037 VSS VSS nch w=0.39u l=0.06u
MI14-M_u2 Z net037 VSS VSS nch w=0.39u l=0.06u
M_u16 VDD net017 net037 VDD pch w=0.52u l=0.06u
MI3 VDD I net037 VDD pch w=0.52u l=0.06u
MI13-M_u3 net017 ISO VDD VDD pch w=0.26u l=0.06u
M_u3-M_u3 Z net037 VDD VDD pch w=0.52u l=0.06u
MI14-M_u3 Z net037 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt ISOLOD4 ISO I Z VDD VSS
MI13 net021 p0 VSS VSS nch w=0.39u l=0.06u
MI12 net016 I net021 VSS nch w=0.39u l=0.06u
MI4_0-M_u2 Z net016 VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 Z net016 VSS VSS nch w=0.39u l=0.06u
MI4_2-M_u2 Z net016 VSS VSS nch w=0.39u l=0.06u
MI4_3-M_u2 Z net016 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 p0 ISO VSS VSS nch w=0.195u l=0.06u
M_u16 VDD p0 net016 VDD pch w=0.52u l=0.06u
MI11 VDD I net016 VDD pch w=0.52u l=0.06u
MI4_0-M_u3 Z net016 VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 Z net016 VDD VDD pch w=0.52u l=0.06u
MI4_2-M_u3 Z net016 VDD VDD pch w=0.52u l=0.06u
MI4_3-M_u3 Z net016 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 p0 ISO VDD VDD pch w=0.26u l=0.06u
.ends
.subckt ISOLOD8 ISO I Z VDD VSS
MI13_0 net21<0> p0 VSS VSS nch w=0.39u l=0.06u
MI13_1 net21<1> p0 VSS VSS nch w=0.39u l=0.06u
MI13_2 net21<2> p0 VSS VSS nch w=0.39u l=0.06u
MI12_0 P1 I net21<0> VSS nch w=0.39u l=0.06u
MI12_1 P1 I net21<1> VSS nch w=0.39u l=0.06u
MI12_2 P1 I net21<2> VSS nch w=0.39u l=0.06u
MI4_0-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_1-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_2-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_3-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_4-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_5-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_6-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI4_7-M_u2 Z P1 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 p0 ISO VSS VSS nch w=0.39u l=0.06u
M_u16_0 VDD p0 P1 VDD pch w=0.52u l=0.06u
M_u16_1 VDD p0 P1 VDD pch w=0.52u l=0.06u
M_u16_2 VDD p0 P1 VDD pch w=0.52u l=0.06u
MI11_0 VDD I P1 VDD pch w=0.52u l=0.06u
MI11_1 VDD I P1 VDD pch w=0.52u l=0.06u
MI11_2 VDD I P1 VDD pch w=0.52u l=0.06u
MI4_0-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_1-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_2-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_3-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_4-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_5-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_6-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI4_7-M_u3 Z P1 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 p0 ISO VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLHLD1 I Z VDD VSS
MI1-M_u2 Z net6 VSS VSS nch w=0.39u l=0.06u
MI2-M_u2 net6 I VSS VSS nch w=0.195u l=0.06u
MI1-M_u3 Z net6 VDD VDD pch w=0.52u l=0.06u
MI2-M_u3 net6 I VDD VDD pch w=0.26u l=0.06u
.ends
.subckt LVLHLD2 I Z VDD VSS
M_u2-M_u2 net8 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z net8 VSS VSS nch w=0.39u l=0.06u
M_u2-M_u3 net8 I VDD VDD pch w=0.52u l=0.06u
M_u3_0-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z net8 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLHLD4 I Z VDD VSS
M_u3_0-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_1-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_2-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u3_3-M_u2 Z p0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 p0 I VSS VSS nch w=0.39u l=0.06u
M_u3_0-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_1-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_2-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u3_3-M_u3 Z p0 VDD VDD pch w=0.52u l=0.06u
M_u2_0-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 p0 I VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLHLD8 I Z VDD VSS
M_u2_0-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_1-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u2_2-M_u2 n0 I VSS VSS nch w=0.39u l=0.06u
M_u7_0-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_1-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_2-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_3-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_4-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_5-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_6-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u7_7-M_u2 Z n0 VSS VSS nch w=0.39u l=0.06u
M_u2_0-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_1-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u2_2-M_u3 n0 I VDD VDD pch w=0.52u l=0.06u
M_u7_0-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_1-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_2-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_3-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_4-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_5-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_6-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
M_u7_7-M_u3 Z n0 VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLLHCD1 I NSLEEP Z VDD VDDL VSS
MI16 Z net031 vvss VSS nch w=0.39u l=0.06u
MI44 net024 I vvss VSS nch w=0.39u l=0.06u
MI43_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI43_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI43_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40_0 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_1 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_2 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_3 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI42_0 net031 I vvss VSS nch w=0.39u l=0.06u
MI42_1 net031 I vvss VSS nch w=0.39u l=0.06u
MI42_2 net031 I vvss VSS nch w=0.39u l=0.06u
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net031 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net031 net34 VDD pch w=0.15u l=0.06u
MI15 VDD net031 Z VDD pch w=0.52u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LVLLHCD2 I NSLEEP Z VDD VDDL VSS
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net043 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net043 net34 VDD pch w=0.15u l=0.06u
MI15_0 VDD net043 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net043 Z VDD pch w=0.52u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.34u l=0.06u
MI16_0 Z net043 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net043 vvss VSS nch w=0.39u l=0.06u
MI45 net024 I vvss VSS nch w=0.39u l=0.06u
MI44_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI44_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI44_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40_0 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_1 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_2 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_3 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI43_0 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_1 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_2 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_3 net043 I vvss VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHCD4 I NSLEEP Z VDD VDDL VSS
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net038 net34 VDD VDD pch w=0.15u l=0.06u
MI15_0 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD net038 Z VDD pch w=0.52u l=0.06u
MI37 VDD net038 net34 VDD pch w=0.15u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
MI45_0 net038 I vvss VSS nch w=0.39u l=0.06u
MI45_1 net038 I vvss VSS nch w=0.39u l=0.06u
MI45_2 net038 I vvss VSS nch w=0.39u l=0.06u
MI46_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40 vvss NSLEEP VSS VSS nch w=3.11u l=0.06u
MI16_0 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_2 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_3 Z net038 vvss VSS nch w=0.39u l=0.06u
MI47 net024 I vvss VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHCD8 I NSLEEP Z VDD VDDL VSS
MI45_0 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_1 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_2 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_3 net087 I vvss VSS nch w=0.39u l=0.06u
MI46_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI16_0 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_2 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_3 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_4 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_5 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_6 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_7 Z net087 vvss VSS nch w=0.39u l=0.06u
MI40 vvss NSLEEP VSS VSS nch w=6.26u l=0.06u
MI47 net024 I vvss VSS nch w=0.39u l=0.06u
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net087 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net087 net34 VDD pch w=0.15u l=0.06u
MI15_0 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_4 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_5 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_6 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_7 VDD net087 Z VDD pch w=0.52u l=0.06u
MI41_0 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
MI41_1 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLLHD1 I Z VDD VDDL VSS
MI15 VDD net25 Z VDD pch w=0.52u l=0.06u
MI5 VDD net25 net34 VDD pch w=0.15u l=0.06u
MI19 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI17 net25 net34 VDD VDD pch w=0.15u l=0.06u
MI6_0 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_1 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_2 net25 I VSS VSS nch w=0.39u l=0.06u
MI16 Z net25 VSS VSS nch w=0.39u l=0.06u
MI8_1 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_2 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_0 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI21 net024 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHD2 I Z VDD VDDL VSS
MI15_0 VDD net25 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net25 Z VDD pch w=0.52u l=0.06u
MI5 VDD net25 net34 VDD pch w=0.15u l=0.06u
MI19 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI17 net25 net34 VDD VDD pch w=0.15u l=0.06u
MI6_0 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_1 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_2 net25 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z net25 VSS VSS nch w=0.39u l=0.06u
MI8_0 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_1 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z net25 VSS VSS nch w=0.39u l=0.06u
MI21 net024 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHD4 I Z VDD VDDL VSS
MI15_0 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD p0 Z VDD pch w=0.52u l=0.06u
MI5 VDD p0 net031 VDD pch w=0.15u l=0.06u
MI19 net49 I VDDL VDDL pch w=0.52u l=0.06u
MI17 p0 net031 VDD VDD pch w=0.15u l=0.06u
MI6_0 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_1 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_2 p0 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_3 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_1 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI21 net49 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHD8 I Z VDD VDDL VSS
MI15_0 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_4 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_5 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_6 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_7 VDD p0 Z VDD pch w=0.52u l=0.06u
MI5 VDD p0 net031 VDD pch w=0.15u l=0.06u
MI19 net49 I VDDL VDDL pch w=0.52u l=0.06u
MI17 p0 net031 VDD VDD pch w=0.15u l=0.06u
MI6_0 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_1 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_2 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_3 p0 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_3 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_4 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_5 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_6 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_7 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_1 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_2 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI21 net49 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFACD1 I NSLEEP Z VDD VDDL VSS
MI16 Z net031 vvss VSS nch w=0.39u l=0.06u
MI44 net024 I vvss VSS nch w=0.39u l=0.06u
MI43_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI43_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI43_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40_0 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_1 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_2 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_3 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI42_0 net031 I vvss VSS nch w=0.39u l=0.06u
MI42_1 net031 I vvss VSS nch w=0.39u l=0.06u
MI42_2 net031 I vvss VSS nch w=0.39u l=0.06u
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net031 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net031 net34 VDD pch w=0.15u l=0.06u
MI15 VDD net031 Z VDD pch w=0.52u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.15u l=0.06u
.ends
.subckt LVLLHFACD2 I NSLEEP Z VDD VDDL VSS
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net043 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net043 net34 VDD pch w=0.15u l=0.06u
MI15_0 VDD net043 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net043 Z VDD pch w=0.52u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.34u l=0.06u
MI16_0 Z net043 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net043 vvss VSS nch w=0.39u l=0.06u
MI45 net024 I vvss VSS nch w=0.39u l=0.06u
MI44_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI44_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI44_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40_0 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_1 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_2 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI40_3 vvss NSLEEP VSS VSS nch w=0.39u l=0.06u
MI43_0 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_1 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_2 net043 I vvss VSS nch w=0.39u l=0.06u
MI43_3 net043 I vvss VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFACD4 I NSLEEP Z VDD VDDL VSS
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net038 net34 VDD VDD pch w=0.15u l=0.06u
MI15_0 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD net038 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD net038 Z VDD pch w=0.52u l=0.06u
MI37 VDD net038 net34 VDD pch w=0.15u l=0.06u
MI41 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
MI45_0 net038 I vvss VSS nch w=0.39u l=0.06u
MI45_1 net038 I vvss VSS nch w=0.39u l=0.06u
MI45_2 net038 I vvss VSS nch w=0.39u l=0.06u
MI46_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI40 vvss NSLEEP VSS VSS nch w=3.11u l=0.06u
MI16_0 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_2 Z net038 vvss VSS nch w=0.39u l=0.06u
MI16_3 Z net038 vvss VSS nch w=0.39u l=0.06u
MI47 net024 I vvss VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFACD8 I NSLEEP Z VDD VDDL VSS
MI45_0 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_1 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_2 net087 I vvss VSS nch w=0.39u l=0.06u
MI45_3 net087 I vvss VSS nch w=0.39u l=0.06u
MI46_0 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_1 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI46_2 net34 net024 vvss VSS nch w=0.39u l=0.06u
MI16_0 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_1 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_2 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_3 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_4 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_5 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_6 Z net087 vvss VSS nch w=0.39u l=0.06u
MI16_7 Z net087 vvss VSS nch w=0.39u l=0.06u
MI40 vvss NSLEEP VSS VSS nch w=6.26u l=0.06u
MI47 net024 I vvss VSS nch w=0.39u l=0.06u
MI33 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI36 net087 net34 VDD VDD pch w=0.15u l=0.06u
MI37 VDD net087 net34 VDD pch w=0.15u l=0.06u
MI15_0 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_4 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_5 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_6 VDD net087 Z VDD pch w=0.52u l=0.06u
MI15_7 VDD net087 Z VDD pch w=0.52u l=0.06u
MI41_0 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
MI41_1 Z NSLEEP VDD VDD pch w=0.52u l=0.06u
.ends
.subckt LVLLHFAD1 I Z VDD VDDL VSS
MI15 VDD net25 Z VDD pch w=0.52u l=0.06u
MI5 VDD net25 net34 VDD pch w=0.15u l=0.06u
MI19 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI17 net25 net34 VDD VDD pch w=0.15u l=0.06u
MI6_0 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_1 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_2 net25 I VSS VSS nch w=0.39u l=0.06u
MI16 Z net25 VSS VSS nch w=0.39u l=0.06u
MI8_1 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_2 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_0 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI21 net024 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFAD2 I Z VDD VDDL VSS
MI15_0 VDD net25 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD net25 Z VDD pch w=0.52u l=0.06u
MI5 VDD net25 net34 VDD pch w=0.15u l=0.06u
MI19 net024 I VDDL VDDL pch w=0.52u l=0.06u
MI17 net25 net34 VDD VDD pch w=0.15u l=0.06u
MI6_0 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_1 net25 I VSS VSS nch w=0.39u l=0.06u
MI6_2 net25 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z net25 VSS VSS nch w=0.39u l=0.06u
MI8_0 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI8_1 net34 net024 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z net25 VSS VSS nch w=0.39u l=0.06u
MI21 net024 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFAD4 I Z VDD VDDL VSS
MI15_0 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD p0 Z VDD pch w=0.52u l=0.06u
MI5 VDD p0 net031 VDD pch w=0.15u l=0.06u
MI19 net49 I VDDL VDDL pch w=0.52u l=0.06u
MI17 p0 net031 VDD VDD pch w=0.15u l=0.06u
MI6_0 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_1 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_2 p0 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_3 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_1 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI21 net49 I VSS VSS nch w=0.39u l=0.06u
.ends
.subckt LVLLHFAD8 I Z VDD VDDL VSS
MI15_0 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_1 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_2 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_3 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_4 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_5 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_6 VDD p0 Z VDD pch w=0.52u l=0.06u
MI15_7 VDD p0 Z VDD pch w=0.52u l=0.06u
MI5 VDD p0 net031 VDD pch w=0.15u l=0.06u
MI19 net49 I VDDL VDDL pch w=0.52u l=0.06u
MI17 p0 net031 VDD VDD pch w=0.15u l=0.06u
MI6_0 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_1 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_2 p0 I VSS VSS nch w=0.39u l=0.06u
MI6_3 p0 I VSS VSS nch w=0.39u l=0.06u
MI16_0 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_1 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_2 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_3 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_4 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_5 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_6 Z p0 VSS VSS nch w=0.39u l=0.06u
MI16_7 Z p0 VSS VSS nch w=0.39u l=0.06u
MI8_0 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_1 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI8_2 net031 net49 VSS VSS nch w=0.39u l=0.06u
MI21 net49 I VSS VSS nch w=0.39u l=0.06u
.ends
