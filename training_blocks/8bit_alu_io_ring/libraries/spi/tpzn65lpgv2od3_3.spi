M_79 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_80 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_81 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_82 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_83 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_84 PAD net_2304 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_85 VSS net_2318 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2303 net_2303 net_2303 net_2303 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2319 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2320 net_2320 VSS nch_25od w=2.1u l=0.5u
M_89 net_2321 net_2322 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2323 net_2322 net_2321 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2320 net_2322 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2323 net_2322 net_2324 VDDPST pch_25od w=5u l=0.415u
M_93 net_2324 net_2325 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2326 net_2327 net_2302 VDDPST pch_25od w=20u l=0.415u
M_95 net_2326 net_2328 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2302 net_2328 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2327 net_2302 VSS nch_25od w=15u l=0.5u
M_98 net_2329 net_2330 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2331 net_2332 net_2333 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2334 VSS nch_25od w=10u l=0.5u
M_101 net_2335 net_2332 net_2336 VSS nch_25od w=10u l=0.5u
M_102 net_2334 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2334 net_2329 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2334 net_2329 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2336 VSS nch w=10u l=0.09u
M_106 net_2331 net_2330 VSS VSS nch w=10u l=0.09u
M_107 net_2335 I net_2334 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2329 net_2330 net_2333 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2337 net_2338 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2339 net_2332 net_2340 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2341 net_2342 VSS nch_25od w=10u l=0.5u
M_112 net_2343 net_2332 net_2344 VSS nch_25od w=10u l=0.5u
M_113 net_2342 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2342 net_2337 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2342 net_2337 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2341 net_2344 VSS nch w=10u l=0.09u
M_117 net_2339 net_2338 VSS VSS nch w=10u l=0.09u
M_118 net_2343 net_2341 net_2342 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2337 net_2338 net_2340 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2345 net_2346 VDDPST pch_25od w=40u l=0.415u
M_121 net_2346 net_2347 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2348 net_2345 net_2346 VSS nch_25od w=20u l=0.5u
M_123 net_2348 net_2347 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2349 net_2341 VSS nch w=3u l=0.1u
M_125 net_2349 net_2341 VDD VDD pch w=4u l=0.1u
M_126 net_2341 net_2349 net_2349 VDD pch w=4u l=0.1u
M_127 net_2318 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2319 net_2350 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2318 net_2349 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2318 net_2319 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2319 net_2318 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2332 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2332 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2325 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2301 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2351 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2315 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2349 ndio area=4p
D_139 VSS net_2341 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2352 net_2329 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2352 net_2329 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2347 net_2337 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2347 net_2337 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2327 net_2334 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2327 net_2334 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2345 net_2352 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2345 net_2352 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2328 net_2342 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2328 net_2342 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2330 I VSS VSS nch w=3u l=0.09u
M_152 net_2330 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2338 net_2341 VSS VSS nch w=3u l=0.09u
M_154 net_2338 net_2341 VDD VDD pch w=7.5u l=0.09u
M_155 net_2350 net_2349 VSS VSS nch w=3u l=0.09u
M_156 net_2350 net_2349 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2353 net_2354 VSS nch w=20u l=0.09u
M_158 VSS net_2355 net_2353 VSS nch w=10u l=0.09u
M_159 VDD net_2353 net_2354 VDD pch w=30u l=0.09u
M_160 VDD net_2355 net_2353 VDD pch w=10u l=0.09u
M_161 VSS net_2323 net_2356 VSS nch_25od w=0.6u l=0.5u
M_162 net_2355 net_2356 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2357 net_2347 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2358 net_2351 net_2357 VSS nch_25od w=10u l=0.5u
M_165 net_2304 net_2351 net_2346 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2323 net_2355 VSS nch_25od w=5u l=0.5u
M_167 net_2325 net_2351 net_2359 VSS nch_25od w=30u l=0.5u
M_168 net_2360 net_2351 net_2358 VSS nch_25od w=10u l=0.5u
M_169 net_2359 net_2328 net_2360 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2323 net_2356 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2358 net_2351 net_2325 net_2303 pch_25od w=26u l=0.415u
M_172 net_2304 net_2358 net_2346 net_2303 pch_25od w=26u l=0.415u
M_173 VDD net_2323 net_2355 VDD pch_25od w=5u l=0.415u
M_174 net_2303 net_2358 VDDPST net_2303 pch_25od w=24u l=0.415u
M_175 net_2303 net_2351 net_2325 net_2303 pch_25od w=24u l=0.415u
M_176 net_2304 net_2351 net_2325 net_2303 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO04CDG
.SUBCKT PDO08CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2362 net_2362 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2362 net_2362 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2362 net_2362 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2362 net_2362 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2361 net_2361 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_14 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_15 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_16 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_17 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_18 net_2363 net_2363 rppolywo w=0.4u l=1.3u m=1
X_19 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_20 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_21 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_22 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_23 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_24 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_25 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_26 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_27 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
X_28 net_2364 net_2364 rppolywo w=0.4u l=1.3u m=1
M_29 net_2365 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2366 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2367 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2368 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2369 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2370 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2371 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2372 net_2361 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_2373 net_2365 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2373 net_2366 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2373 net_2367 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2373 net_2368 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2373 net_2369 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2373 net_2370 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2373 net_2371 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2373 net_2372 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2373 net_2374 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2373 net_2375 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2373 net_2376 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2373 net_2377 VSS nch_25od w=33u l=0.5u
M_49 net_2374 net_2362 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2375 net_2362 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2376 net_2362 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2377 net_2362 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_54 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_55 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_56 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_57 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_58 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_59 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_60 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_61 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_62 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_63 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_64 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_65 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_66 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_67 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_68 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_69 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_70 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_71 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_72 PAD net_2364 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_73 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_74 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_75 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_76 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_77 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_78 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_79 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_80 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_81 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_82 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_83 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_84 PAD net_2363 VDDPST net_2364 pch_25od w=16.5u l=0.415u
M_85 VSS net_2378 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2364 net_2364 net_2364 net_2364 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2379 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2380 net_2380 VSS nch_25od w=2.1u l=0.5u
M_89 net_2381 net_2382 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2383 net_2382 net_2381 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2380 net_2382 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2383 net_2382 net_2384 VDDPST pch_25od w=5u l=0.415u
M_93 net_2384 net_2385 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2386 net_2387 net_2362 VDDPST pch_25od w=20u l=0.415u
M_95 net_2386 net_2388 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2362 net_2388 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2387 net_2362 VSS nch_25od w=15u l=0.5u
M_98 net_2389 net_2390 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2391 net_2392 net_2393 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2394 VSS nch_25od w=10u l=0.5u
M_101 net_2395 net_2392 net_2396 VSS nch_25od w=10u l=0.5u
M_102 net_2394 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2394 net_2389 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2394 net_2389 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2396 VSS nch w=10u l=0.09u
M_106 net_2391 net_2390 VSS VSS nch w=10u l=0.09u
M_107 net_2395 I net_2394 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2389 net_2390 net_2393 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2397 net_2398 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2399 net_2392 net_2400 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2401 net_2402 VSS nch_25od w=10u l=0.5u
M_112 net_2403 net_2392 net_2404 VSS nch_25od w=10u l=0.5u
M_113 net_2402 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2402 net_2397 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2402 net_2397 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2401 net_2404 VSS nch w=10u l=0.09u
M_117 net_2399 net_2398 VSS VSS nch w=10u l=0.09u
M_118 net_2403 net_2401 net_2402 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2397 net_2398 net_2400 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2405 net_2406 VDDPST pch_25od w=40u l=0.415u
M_121 net_2406 net_2407 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2408 net_2405 net_2406 VSS nch_25od w=20u l=0.5u
M_123 net_2408 net_2407 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2409 net_2401 VSS nch w=3u l=0.1u
M_125 net_2409 net_2401 VDD VDD pch w=4u l=0.1u
M_126 net_2401 net_2409 net_2409 VDD pch w=4u l=0.1u
M_127 net_2378 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2379 net_2410 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2378 net_2409 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2378 net_2379 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2379 net_2378 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2392 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2392 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2385 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2361 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2411 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2373 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2409 ndio area=4p
D_139 VSS net_2401 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2412 net_2389 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2412 net_2389 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2407 net_2397 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2407 net_2397 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2387 net_2394 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2387 net_2394 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2405 net_2412 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2405 net_2412 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2388 net_2402 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2388 net_2402 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2390 I VSS VSS nch w=3u l=0.09u
M_152 net_2390 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2398 net_2401 VSS VSS nch w=3u l=0.09u
M_154 net_2398 net_2401 VDD VDD pch w=7.5u l=0.09u
M_155 net_2410 net_2409 VSS VSS nch w=3u l=0.09u
M_156 net_2410 net_2409 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2413 net_2414 VSS nch w=20u l=0.09u
M_158 VSS net_2415 net_2413 VSS nch w=10u l=0.09u
M_159 VDD net_2413 net_2414 VDD pch w=30u l=0.09u
M_160 VDD net_2415 net_2413 VDD pch w=10u l=0.09u
M_161 VSS net_2383 net_2416 VSS nch_25od w=0.6u l=0.5u
M_162 net_2415 net_2416 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2417 net_2407 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2418 net_2411 net_2417 VSS nch_25od w=10u l=0.5u
M_165 net_2363 net_2411 net_2406 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2383 net_2415 VSS nch_25od w=5u l=0.5u
M_167 net_2385 net_2411 net_2419 VSS nch_25od w=30u l=0.5u
M_168 net_2420 net_2411 net_2418 VSS nch_25od w=10u l=0.5u
M_169 net_2419 net_2388 net_2420 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2383 net_2416 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2418 net_2411 net_2385 net_2364 pch_25od w=26u l=0.415u
M_172 net_2363 net_2418 net_2406 net_2364 pch_25od w=26u l=0.415u
M_173 VDD net_2383 net_2415 VDD pch_25od w=5u l=0.415u
M_174 net_2364 net_2418 VDDPST net_2364 pch_25od w=24u l=0.415u
M_175 net_2364 net_2411 net_2385 net_2364 pch_25od w=24u l=0.415u
M_176 net_2363 net_2411 net_2385 net_2364 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO08CDG
.SUBCKT PDO12CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2421 net_2421 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2422 net_2422 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_14 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_15 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_16 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_17 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_18 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_19 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_20 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_21 net_2423 net_2423 rppolywo w=0.4u l=1.3u m=1
X_22 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_23 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_24 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_25 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_26 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_27 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
X_28 net_2424 net_2424 rppolywo w=0.4u l=1.3u m=1
M_29 net_2425 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2426 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2427 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2428 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2429 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2430 net_2422 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_2431 net_2425 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2431 net_2426 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2431 net_2427 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2431 net_2428 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2431 net_2429 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2431 net_2430 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2431 net_2432 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2431 net_2433 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2431 net_2434 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2431 net_2435 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2431 net_2436 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2431 net_2437 VSS nch_25od w=33u l=0.5u
M_47 net_2432 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2433 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2434 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2435 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2436 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2437 net_2421 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_54 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_55 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_56 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_57 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_58 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_59 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_60 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_61 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_62 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_63 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_64 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_65 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_66 PAD net_2424 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_67 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_68 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_69 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_70 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_71 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_72 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_73 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_74 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_75 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_76 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_77 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_78 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_79 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_80 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_81 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_82 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_83 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_84 PAD net_2423 VDDPST net_2424 pch_25od w=16.5u l=0.415u
M_85 VSS net_2438 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2424 net_2424 net_2424 net_2424 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2439 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2440 net_2440 VSS nch_25od w=2.1u l=0.5u
M_89 net_2441 net_2442 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2443 net_2442 net_2441 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2440 net_2442 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2443 net_2442 net_2444 VDDPST pch_25od w=5u l=0.415u
M_93 net_2444 net_2445 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2446 net_2447 net_2421 VDDPST pch_25od w=20u l=0.415u
M_95 net_2446 net_2448 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2421 net_2448 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2447 net_2421 VSS nch_25od w=15u l=0.5u
M_98 net_2449 net_2450 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2451 net_2452 net_2453 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2454 VSS nch_25od w=10u l=0.5u
M_101 net_2455 net_2452 net_2456 VSS nch_25od w=10u l=0.5u
M_102 net_2454 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2454 net_2449 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2454 net_2449 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2456 VSS nch w=10u l=0.09u
M_106 net_2451 net_2450 VSS VSS nch w=10u l=0.09u
M_107 net_2455 I net_2454 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2449 net_2450 net_2453 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2457 net_2458 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2459 net_2452 net_2460 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2461 net_2462 VSS nch_25od w=10u l=0.5u
M_112 net_2463 net_2452 net_2464 VSS nch_25od w=10u l=0.5u
M_113 net_2462 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2462 net_2457 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2462 net_2457 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2461 net_2464 VSS nch w=10u l=0.09u
M_117 net_2459 net_2458 VSS VSS nch w=10u l=0.09u
M_118 net_2463 net_2461 net_2462 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2457 net_2458 net_2460 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2465 net_2466 VDDPST pch_25od w=40u l=0.415u
M_121 net_2466 net_2467 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2468 net_2465 net_2466 VSS nch_25od w=20u l=0.5u
M_123 net_2468 net_2467 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2469 net_2461 VSS nch w=3u l=0.1u
M_125 net_2469 net_2461 VDD VDD pch w=4u l=0.1u
M_126 net_2461 net_2469 net_2469 VDD pch w=4u l=0.1u
M_127 net_2438 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2439 net_2470 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2438 net_2469 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2438 net_2439 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2439 net_2438 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2452 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2452 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2445 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2422 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2471 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2431 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2469 ndio area=4p
D_139 VSS net_2461 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2472 net_2449 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2472 net_2449 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2467 net_2457 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2467 net_2457 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2447 net_2454 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2447 net_2454 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2465 net_2472 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2465 net_2472 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2448 net_2462 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2448 net_2462 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2450 I VSS VSS nch w=3u l=0.09u
M_152 net_2450 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2458 net_2461 VSS VSS nch w=3u l=0.09u
M_154 net_2458 net_2461 VDD VDD pch w=7.5u l=0.09u
M_155 net_2470 net_2469 VSS VSS nch w=3u l=0.09u
M_156 net_2470 net_2469 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2473 net_2474 VSS nch w=20u l=0.09u
M_158 VSS net_2475 net_2473 VSS nch w=10u l=0.09u
M_159 VDD net_2473 net_2474 VDD pch w=30u l=0.09u
M_160 VDD net_2475 net_2473 VDD pch w=10u l=0.09u
M_161 VSS net_2443 net_2476 VSS nch_25od w=0.6u l=0.5u
M_162 net_2475 net_2476 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2477 net_2467 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2478 net_2471 net_2477 VSS nch_25od w=10u l=0.5u
M_165 net_2423 net_2471 net_2466 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2443 net_2475 VSS nch_25od w=5u l=0.5u
M_167 net_2445 net_2471 net_2479 VSS nch_25od w=30u l=0.5u
M_168 net_2480 net_2471 net_2478 VSS nch_25od w=10u l=0.5u
M_169 net_2479 net_2448 net_2480 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2443 net_2476 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2478 net_2471 net_2445 net_2424 pch_25od w=26u l=0.415u
M_172 net_2423 net_2478 net_2466 net_2424 pch_25od w=26u l=0.415u
M_173 VDD net_2443 net_2475 VDD pch_25od w=5u l=0.415u
M_174 net_2424 net_2478 VDDPST net_2424 pch_25od w=24u l=0.415u
M_175 net_2424 net_2471 net_2445 net_2424 pch_25od w=24u l=0.415u
M_176 net_2423 net_2471 net_2445 net_2424 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO12CDG
.SUBCKT PDO16CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2481 net_2481 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2481 net_2481 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2481 net_2481 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2481 net_2481 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2482 net_2482 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_14 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_15 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_16 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_17 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_18 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_19 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_20 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_21 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_22 net_2484 net_2484 rppolywo w=0.4u l=1.3u m=1
X_23 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_24 net_2484 net_2484 rppolywo w=0.4u l=1.3u m=1
X_25 net_2484 net_2484 rppolywo w=0.4u l=1.3u m=1
X_26 net_2484 net_2484 rppolywo w=0.4u l=1.3u m=1
X_27 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
X_28 net_2483 net_2483 rppolywo w=0.4u l=1.3u m=1
M_29 net_2485 net_2481 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2486 net_2481 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2487 net_2481 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2488 net_2481 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_2489 net_2485 VSS nch_25od w=33u l=0.5u
M_34 PAD net_2489 net_2486 VSS nch_25od w=33u l=0.5u
M_35 PAD net_2489 net_2487 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2489 net_2488 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2489 net_2490 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2489 net_2491 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2489 net_2492 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2489 net_2493 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2489 net_2494 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2489 net_2495 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2489 net_2496 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2489 net_2497 VSS nch_25od w=33u l=0.5u
M_45 net_2490 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_46 net_2491 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_47 net_2492 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2493 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2494 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2495 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2496 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2497 net_2482 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_54 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_55 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_56 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_57 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_58 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_59 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_60 PAD net_2484 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_61 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_62 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_63 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_64 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_65 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_66 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_67 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_68 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_69 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_70 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_71 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_72 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_73 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_74 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_75 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_76 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_77 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_78 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_79 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_80 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_81 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_82 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_83 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_84 PAD net_2483 VDDPST net_2484 pch_25od w=16.5u l=0.415u
M_85 VSS net_2498 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2484 net_2484 net_2484 net_2484 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2499 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2500 net_2500 VSS nch_25od w=2.1u l=0.5u
M_89 net_2501 net_2502 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2503 net_2502 net_2501 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2500 net_2502 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2503 net_2502 net_2504 VDDPST pch_25od w=5u l=0.415u
M_93 net_2504 net_2505 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2506 net_2507 net_2482 VDDPST pch_25od w=20u l=0.415u
M_95 net_2506 net_2508 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2482 net_2508 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2507 net_2482 VSS nch_25od w=15u l=0.5u
M_98 net_2509 net_2510 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2511 net_2512 net_2513 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2514 VSS nch_25od w=10u l=0.5u
M_101 net_2515 net_2512 net_2516 VSS nch_25od w=10u l=0.5u
M_102 net_2514 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2514 net_2509 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2514 net_2509 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2516 VSS nch w=10u l=0.09u
M_106 net_2511 net_2510 VSS VSS nch w=10u l=0.09u
M_107 net_2515 I net_2514 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2509 net_2510 net_2513 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2517 net_2518 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2519 net_2512 net_2520 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2521 net_2522 VSS nch_25od w=10u l=0.5u
M_112 net_2523 net_2512 net_2524 VSS nch_25od w=10u l=0.5u
M_113 net_2522 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2522 net_2517 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2522 net_2517 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2521 net_2524 VSS nch w=10u l=0.09u
M_117 net_2519 net_2518 VSS VSS nch w=10u l=0.09u
M_118 net_2523 net_2521 net_2522 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2517 net_2518 net_2520 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2525 net_2526 VDDPST pch_25od w=40u l=0.415u
M_121 net_2526 net_2527 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2528 net_2525 net_2526 VSS nch_25od w=20u l=0.5u
M_123 net_2528 net_2527 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2529 net_2521 VSS nch w=3u l=0.1u
M_125 net_2529 net_2521 VDD VDD pch w=4u l=0.1u
M_126 net_2521 net_2529 net_2529 VDD pch w=4u l=0.1u
M_127 net_2498 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2499 net_2530 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2498 net_2529 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2498 net_2499 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2499 net_2498 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2512 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2512 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2505 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2481 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2531 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2489 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2529 ndio area=4p
D_139 VSS net_2521 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2532 net_2509 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2532 net_2509 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2527 net_2517 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2527 net_2517 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2507 net_2514 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2507 net_2514 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2525 net_2532 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2525 net_2532 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2508 net_2522 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2508 net_2522 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2510 I VSS VSS nch w=3u l=0.09u
M_152 net_2510 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2518 net_2521 VSS VSS nch w=3u l=0.09u
M_154 net_2518 net_2521 VDD VDD pch w=7.5u l=0.09u
M_155 net_2530 net_2529 VSS VSS nch w=3u l=0.09u
M_156 net_2530 net_2529 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2533 net_2534 VSS nch w=20u l=0.09u
M_158 VSS net_2535 net_2533 VSS nch w=10u l=0.09u
M_159 VDD net_2533 net_2534 VDD pch w=30u l=0.09u
M_160 VDD net_2535 net_2533 VDD pch w=10u l=0.09u
M_161 VSS net_2503 net_2536 VSS nch_25od w=0.6u l=0.5u
M_162 net_2535 net_2536 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2537 net_2527 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2538 net_2531 net_2537 VSS nch_25od w=10u l=0.5u
M_165 net_2483 net_2531 net_2526 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2503 net_2535 VSS nch_25od w=5u l=0.5u
M_167 net_2505 net_2531 net_2539 VSS nch_25od w=30u l=0.5u
M_168 net_2540 net_2531 net_2538 VSS nch_25od w=10u l=0.5u
M_169 net_2539 net_2508 net_2540 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2503 net_2536 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2538 net_2531 net_2505 net_2484 pch_25od w=26u l=0.415u
M_172 net_2483 net_2538 net_2526 net_2484 pch_25od w=26u l=0.415u
M_173 VDD net_2503 net_2535 VDD pch_25od w=5u l=0.415u
M_174 net_2484 net_2538 VDDPST net_2484 pch_25od w=24u l=0.415u
M_175 net_2484 net_2531 net_2505 net_2484 pch_25od w=24u l=0.415u
M_176 net_2483 net_2531 net_2505 net_2484 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO16CDG
.SUBCKT PDO24CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2541 net_2541 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_14 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_15 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_16 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_17 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_18 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_19 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_20 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_21 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_22 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_23 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_24 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_25 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_26 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_27 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
X_28 net_2542 net_2542 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_2543 net_2544 VSS nch_25od w=33u l=0.5u
M_30 PAD net_2543 net_2545 VSS nch_25od w=33u l=0.5u
M_31 PAD net_2543 net_2546 VSS nch_25od w=33u l=0.5u
M_32 PAD net_2543 net_2547 VSS nch_25od w=33u l=0.5u
M_33 PAD net_2543 net_2548 VSS nch_25od w=33u l=0.5u
M_34 PAD net_2543 net_2549 VSS nch_25od w=33u l=0.5u
M_35 PAD net_2543 net_2550 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2543 net_2551 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2543 net_2552 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2543 net_2553 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2543 net_2554 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2543 net_2555 VSS nch_25od w=33u l=0.5u
M_41 net_2544 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_42 net_2545 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_43 net_2546 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_44 net_2547 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_45 net_2548 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_46 net_2549 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_47 net_2550 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2551 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2552 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2553 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2554 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2555 net_2541 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_54 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_55 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_56 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_57 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_58 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_59 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_60 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_61 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_62 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_63 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_64 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_65 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_66 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_67 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_68 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_69 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_70 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_71 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_72 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_73 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_74 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_75 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_76 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_77 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_78 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_79 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_80 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_81 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_82 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_83 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_84 PAD net_2542 VDDPST net_2556 pch_25od w=16.5u l=0.415u
M_85 VSS net_2557 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2556 net_2556 net_2556 net_2556 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2558 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2559 net_2559 VSS nch_25od w=2.1u l=0.5u
M_89 net_2560 net_2561 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2562 net_2561 net_2560 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2559 net_2561 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2562 net_2561 net_2563 VDDPST pch_25od w=5u l=0.415u
M_93 net_2563 net_2564 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2565 net_2566 net_2541 VDDPST pch_25od w=20u l=0.415u
M_95 net_2565 net_2567 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2541 net_2567 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2566 net_2541 VSS nch_25od w=15u l=0.5u
M_98 net_2568 net_2569 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2570 net_2571 net_2572 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2573 VSS nch_25od w=10u l=0.5u
M_101 net_2574 net_2571 net_2575 VSS nch_25od w=10u l=0.5u
M_102 net_2573 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2573 net_2568 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2573 net_2568 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2575 VSS nch w=10u l=0.09u
M_106 net_2570 net_2569 VSS VSS nch w=10u l=0.09u
M_107 net_2574 I net_2573 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2568 net_2569 net_2572 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2576 net_2577 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2578 net_2571 net_2579 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2580 net_2581 VSS nch_25od w=10u l=0.5u
M_112 net_2582 net_2571 net_2583 VSS nch_25od w=10u l=0.5u
M_113 net_2581 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2581 net_2576 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2581 net_2576 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2580 net_2583 VSS nch w=10u l=0.09u
M_117 net_2578 net_2577 VSS VSS nch w=10u l=0.09u
M_118 net_2582 net_2580 net_2581 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2576 net_2577 net_2579 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2584 net_2585 VDDPST pch_25od w=40u l=0.415u
M_121 net_2585 net_2586 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2587 net_2584 net_2585 VSS nch_25od w=20u l=0.5u
M_123 net_2587 net_2586 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2588 net_2580 VSS nch w=3u l=0.1u
M_125 net_2588 net_2580 VDD VDD pch w=4u l=0.1u
M_126 net_2580 net_2588 net_2588 VDD pch w=4u l=0.1u
M_127 net_2557 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2558 net_2589 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2557 net_2588 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2557 net_2558 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2558 net_2557 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2571 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2571 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2564 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2590 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2591 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2543 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2588 ndio area=4p
D_139 VSS net_2580 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2592 net_2568 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2592 net_2568 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2586 net_2576 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2586 net_2576 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2566 net_2573 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2566 net_2573 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2584 net_2592 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2584 net_2592 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2567 net_2581 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2567 net_2581 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2569 I VSS VSS nch w=3u l=0.09u
M_152 net_2569 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2577 net_2580 VSS VSS nch w=3u l=0.09u
M_154 net_2577 net_2580 VDD VDD pch w=7.5u l=0.09u
M_155 net_2589 net_2588 VSS VSS nch w=3u l=0.09u
M_156 net_2589 net_2588 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2593 net_2594 VSS nch w=20u l=0.09u
M_158 VSS net_2595 net_2593 VSS nch w=10u l=0.09u
M_159 VDD net_2593 net_2594 VDD pch w=30u l=0.09u
M_160 VDD net_2595 net_2593 VDD pch w=10u l=0.09u
M_161 VSS net_2562 net_2596 VSS nch_25od w=0.6u l=0.5u
M_162 net_2595 net_2596 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2597 net_2586 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2598 net_2591 net_2597 VSS nch_25od w=10u l=0.5u
M_165 net_2542 net_2591 net_2585 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2562 net_2595 VSS nch_25od w=5u l=0.5u
M_167 net_2564 net_2591 net_2599 VSS nch_25od w=30u l=0.5u
M_168 net_2600 net_2591 net_2598 VSS nch_25od w=10u l=0.5u
M_169 net_2599 net_2567 net_2600 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2562 net_2596 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2598 net_2591 net_2564 net_2556 pch_25od w=26u l=0.415u
M_172 net_2542 net_2598 net_2585 net_2556 pch_25od w=26u l=0.415u
M_173 VDD net_2562 net_2595 VDD pch_25od w=5u l=0.415u
M_174 net_2556 net_2598 VDDPST net_2556 pch_25od w=24u l=0.415u
M_175 net_2556 net_2591 net_2564 net_2556 pch_25od w=24u l=0.415u
M_176 net_2542 net_2591 net_2564 net_2556 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO24CDG
.SUBCKT PDT02DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2602 net_2602 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2602 net_2602 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2601 net_2601 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_14 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_15 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_16 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_17 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_18 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_19 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_20 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_21 net_2604 net_2604 rppolywo w=0.4u l=1.3u m=1
X_22 net_2604 net_2604 rppolywo w=0.4u l=1.3u m=1
X_23 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_24 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_25 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_26 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_27 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
X_28 net_2603 net_2603 rppolywo w=0.4u l=1.3u m=1
M_29 net_2605 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2606 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2607 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2608 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2609 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2610 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2611 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2612 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2613 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2614 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2615 net_2601 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_2616 net_2605 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2616 net_2606 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2616 net_2607 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2616 net_2608 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2616 net_2609 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2616 net_2610 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2616 net_2611 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2616 net_2612 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2616 net_2613 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2616 net_2614 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2616 net_2615 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2616 net_2617 VSS nch_25od w=33u l=0.5u
M_52 net_2617 net_2602 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_54 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_55 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_56 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_57 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_58 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_59 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_60 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_61 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_62 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_63 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_64 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_65 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_66 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_67 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_68 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_69 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_70 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_71 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_72 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_73 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_74 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_75 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_76 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_77 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_78 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_79 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_80 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_81 PAD net_2603 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_82 PAD net_2604 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_83 PAD net_2604 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_84 PAD net_2604 VDDPST net_2603 pch_25od w=16.5u l=0.415u
M_85 VSS net_2618 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2603 net_2603 net_2603 net_2603 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2619 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2620 net_2620 VSS nch_25od w=2.1u l=0.5u
M_89 net_2621 net_2622 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2623 net_2622 net_2621 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2620 net_2622 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2623 net_2622 net_2624 VDDPST pch_25od w=5u l=0.415u
M_93 net_2624 net_2625 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2626 net_2627 net_2602 VDDPST pch_25od w=20u l=0.415u
M_95 net_2626 net_2628 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2602 net_2628 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2627 net_2602 VSS nch_25od w=15u l=0.5u
M_98 net_2629 net_2630 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2631 net_2632 net_2633 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2634 VSS nch_25od w=10u l=0.5u
M_101 net_2635 net_2632 net_2636 VSS nch_25od w=10u l=0.5u
M_102 net_2634 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2634 net_2629 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2634 net_2629 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2636 VSS nch w=10u l=0.09u
M_106 net_2631 net_2630 VSS VSS nch w=10u l=0.09u
M_107 net_2635 I net_2634 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2629 net_2630 net_2633 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2637 net_2638 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2639 net_2632 net_2640 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2641 VSS nch_25od w=10u l=0.5u
M_112 net_2642 net_2632 net_2643 VSS nch_25od w=10u l=0.5u
M_113 net_2641 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2641 net_2637 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2641 net_2637 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2643 VSS nch w=10u l=0.09u
M_117 net_2639 net_2638 VSS VSS nch w=10u l=0.09u
M_118 net_2642 OEN net_2641 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2637 net_2638 net_2640 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2644 net_2645 VDDPST pch_25od w=40u l=0.415u
M_121 net_2645 net_2646 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2647 net_2644 net_2645 VSS nch_25od w=20u l=0.5u
M_123 net_2647 net_2646 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2648 net_2649 VSS nch w=3u l=0.1u
M_125 net_2648 net_2649 VDD VDD pch w=4u l=0.1u
M_126 net_2649 net_2648 net_2648 VDD pch w=4u l=0.1u
M_127 net_2618 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2619 net_2650 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2618 net_2648 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2618 net_2619 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2619 net_2618 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2632 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2632 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2625 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2601 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2651 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2616 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2648 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2652 net_2629 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2652 net_2629 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2646 net_2637 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2646 net_2637 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2627 net_2634 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2627 net_2634 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2644 net_2652 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2644 net_2652 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2628 net_2641 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2628 net_2641 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2630 I VSS VSS nch w=3u l=0.09u
M_152 net_2630 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2638 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2638 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2650 net_2648 VSS VSS nch w=3u l=0.09u
M_156 net_2650 net_2648 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2653 net_2654 VSS nch w=20u l=0.09u
M_158 VSS net_2655 net_2653 VSS nch w=10u l=0.09u
M_159 VDD net_2653 net_2654 VDD pch w=30u l=0.09u
M_160 VDD net_2655 net_2653 VDD pch w=10u l=0.09u
M_161 VSS net_2623 net_2656 VSS nch_25od w=0.6u l=0.5u
M_162 net_2655 net_2656 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2657 net_2646 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2658 net_2651 net_2657 VSS nch_25od w=10u l=0.5u
M_165 net_2604 net_2651 net_2645 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2623 net_2655 VSS nch_25od w=5u l=0.5u
M_167 net_2625 net_2651 net_2659 VSS nch_25od w=30u l=0.5u
M_168 net_2660 net_2651 net_2658 VSS nch_25od w=10u l=0.5u
M_169 net_2659 net_2628 net_2660 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2623 net_2656 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2658 net_2651 net_2625 net_2603 pch_25od w=26u l=0.415u
M_172 net_2604 net_2658 net_2645 net_2603 pch_25od w=26u l=0.415u
M_173 VDD net_2623 net_2655 VDD pch_25od w=5u l=0.415u
M_174 net_2603 net_2658 VDDPST net_2603 pch_25od w=24u l=0.415u
M_175 net_2603 net_2651 net_2625 net_2603 pch_25od w=24u l=0.415u
M_176 net_2604 net_2651 net_2625 net_2603 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT02DGZ
.SUBCKT PDT04DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2662 net_2662 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2662 net_2662 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2661 net_2661 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_14 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_15 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_16 net_2664 net_2664 rppolywo w=0.4u l=1.3u m=1
X_17 net_2664 net_2664 rppolywo w=0.4u l=1.3u m=1
X_18 net_2664 net_2664 rppolywo w=0.4u l=1.3u m=1
X_19 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_20 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_21 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_22 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_23 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_24 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_25 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_26 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_27 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
X_28 net_2663 net_2663 rppolywo w=0.4u l=1.3u m=1
M_29 net_2665 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2666 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2667 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2668 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2669 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2670 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2671 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2672 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2673 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2674 net_2661 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_2675 net_2665 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2675 net_2666 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2675 net_2667 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2675 net_2668 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2675 net_2669 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2675 net_2670 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2675 net_2671 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2675 net_2672 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2675 net_2673 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2675 net_2674 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2675 net_2676 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2675 net_2677 VSS nch_25od w=33u l=0.5u
M_51 net_2676 net_2662 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2677 net_2662 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_54 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_55 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_56 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_57 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_58 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_59 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_60 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_61 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_62 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_63 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_64 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_65 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_66 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_67 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_68 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_69 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_70 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_71 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_72 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_73 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_74 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_75 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_76 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_77 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_78 PAD net_2663 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_79 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_80 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_81 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_82 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_83 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_84 PAD net_2664 VDDPST net_2663 pch_25od w=16.5u l=0.415u
M_85 VSS net_2678 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2663 net_2663 net_2663 net_2663 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2679 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2680 net_2680 VSS nch_25od w=2.1u l=0.5u
M_89 net_2681 net_2682 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2683 net_2682 net_2681 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2680 net_2682 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2683 net_2682 net_2684 VDDPST pch_25od w=5u l=0.415u
M_93 net_2684 net_2685 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2686 net_2687 net_2662 VDDPST pch_25od w=20u l=0.415u
M_95 net_2686 net_2688 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2662 net_2688 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2687 net_2662 VSS nch_25od w=15u l=0.5u
M_98 net_2689 net_2690 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2691 net_2692 net_2693 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2694 VSS nch_25od w=10u l=0.5u
M_101 net_2695 net_2692 net_2696 VSS nch_25od w=10u l=0.5u
M_102 net_2694 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2694 net_2689 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2694 net_2689 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2696 VSS nch w=10u l=0.09u
M_106 net_2691 net_2690 VSS VSS nch w=10u l=0.09u
M_107 net_2695 I net_2694 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2689 net_2690 net_2693 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2697 net_2698 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2699 net_2692 net_2700 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2701 VSS nch_25od w=10u l=0.5u
M_112 net_2702 net_2692 net_2703 VSS nch_25od w=10u l=0.5u
M_113 net_2701 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2701 net_2697 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2701 net_2697 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2703 VSS nch w=10u l=0.09u
M_117 net_2699 net_2698 VSS VSS nch w=10u l=0.09u
M_118 net_2702 OEN net_2701 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2697 net_2698 net_2700 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2704 net_2705 VDDPST pch_25od w=40u l=0.415u
M_121 net_2705 net_2706 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2707 net_2704 net_2705 VSS nch_25od w=20u l=0.5u
M_123 net_2707 net_2706 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2708 net_2709 VSS nch w=3u l=0.1u
M_125 net_2708 net_2709 VDD VDD pch w=4u l=0.1u
M_126 net_2709 net_2708 net_2708 VDD pch w=4u l=0.1u
M_127 net_2678 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2679 net_2710 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2678 net_2708 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2678 net_2679 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2679 net_2678 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2692 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2692 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2685 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2661 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2711 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2675 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2708 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2712 net_2689 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2712 net_2689 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2706 net_2697 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2706 net_2697 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2687 net_2694 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2687 net_2694 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2704 net_2712 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2704 net_2712 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2688 net_2701 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2688 net_2701 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2690 I VSS VSS nch w=3u l=0.09u
M_152 net_2690 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2698 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2698 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2710 net_2708 VSS VSS nch w=3u l=0.09u
M_156 net_2710 net_2708 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2713 net_2714 VSS nch w=20u l=0.09u
M_158 VSS net_2715 net_2713 VSS nch w=10u l=0.09u
M_159 VDD net_2713 net_2714 VDD pch w=30u l=0.09u
M_160 VDD net_2715 net_2713 VDD pch w=10u l=0.09u
M_161 VSS net_2683 net_2716 VSS nch_25od w=0.6u l=0.5u
M_162 net_2715 net_2716 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2717 net_2706 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2718 net_2711 net_2717 VSS nch_25od w=10u l=0.5u
M_165 net_2664 net_2711 net_2705 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2683 net_2715 VSS nch_25od w=5u l=0.5u
M_167 net_2685 net_2711 net_2719 VSS nch_25od w=30u l=0.5u
M_168 net_2720 net_2711 net_2718 VSS nch_25od w=10u l=0.5u
M_169 net_2719 net_2688 net_2720 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2683 net_2716 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2718 net_2711 net_2685 net_2663 pch_25od w=26u l=0.415u
M_172 net_2664 net_2718 net_2705 net_2663 pch_25od w=26u l=0.415u
M_173 VDD net_2683 net_2715 VDD pch_25od w=5u l=0.415u
M_174 net_2663 net_2718 VDDPST net_2663 pch_25od w=24u l=0.415u
M_175 net_2663 net_2711 net_2685 net_2663 pch_25od w=24u l=0.415u
M_176 net_2664 net_2711 net_2685 net_2663 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT04DGZ
.SUBCKT PDT08DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2722 net_2722 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2722 net_2722 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2722 net_2722 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2722 net_2722 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2721 net_2721 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_14 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_15 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_16 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_17 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_18 net_2723 net_2723 rppolywo w=0.4u l=1.3u m=1
X_19 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_20 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_21 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_22 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_23 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_24 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_25 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_26 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_27 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
X_28 net_2724 net_2724 rppolywo w=0.4u l=1.3u m=1
M_29 net_2725 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2726 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2727 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2728 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2729 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2730 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2731 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2732 net_2721 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_2733 net_2725 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2733 net_2726 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2733 net_2727 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2733 net_2728 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2733 net_2729 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2733 net_2730 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2733 net_2731 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2733 net_2732 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2733 net_2734 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2733 net_2735 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2733 net_2736 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2733 net_2737 VSS nch_25od w=33u l=0.5u
M_49 net_2734 net_2722 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2735 net_2722 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2736 net_2722 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2737 net_2722 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_54 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_55 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_56 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_57 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_58 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_59 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_60 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_61 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_62 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_63 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_64 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_65 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_66 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_67 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_68 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_69 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_70 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_71 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_72 PAD net_2724 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_73 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_74 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_75 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_76 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_77 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_78 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_79 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_80 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_81 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_82 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_83 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_84 PAD net_2723 VDDPST net_2724 pch_25od w=16.5u l=0.415u
M_85 VSS net_2738 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2724 net_2724 net_2724 net_2724 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2739 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2740 net_2740 VSS nch_25od w=2.1u l=0.5u
M_89 net_2741 net_2742 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2743 net_2742 net_2741 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2740 net_2742 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2743 net_2742 net_2744 VDDPST pch_25od w=5u l=0.415u
M_93 net_2744 net_2745 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2746 net_2747 net_2722 VDDPST pch_25od w=20u l=0.415u
M_95 net_2746 net_2748 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2722 net_2748 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2747 net_2722 VSS nch_25od w=15u l=0.5u
M_98 net_2749 net_2750 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2751 net_2752 net_2753 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2754 VSS nch_25od w=10u l=0.5u
M_101 net_2755 net_2752 net_2756 VSS nch_25od w=10u l=0.5u
M_102 net_2754 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2754 net_2749 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2754 net_2749 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2756 VSS nch w=10u l=0.09u
M_106 net_2751 net_2750 VSS VSS nch w=10u l=0.09u
M_107 net_2755 I net_2754 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2749 net_2750 net_2753 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2757 net_2758 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2759 net_2752 net_2760 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2761 VSS nch_25od w=10u l=0.5u
M_112 net_2762 net_2752 net_2763 VSS nch_25od w=10u l=0.5u
M_113 net_2761 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2761 net_2757 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2761 net_2757 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2763 VSS nch w=10u l=0.09u
M_117 net_2759 net_2758 VSS VSS nch w=10u l=0.09u
M_118 net_2762 OEN net_2761 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2757 net_2758 net_2760 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2764 net_2765 VDDPST pch_25od w=40u l=0.415u
M_121 net_2765 net_2766 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2767 net_2764 net_2765 VSS nch_25od w=20u l=0.5u
M_123 net_2767 net_2766 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2768 net_2769 VSS nch w=3u l=0.1u
M_125 net_2768 net_2769 VDD VDD pch w=4u l=0.1u
M_126 net_2769 net_2768 net_2768 VDD pch w=4u l=0.1u
M_127 net_2738 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2739 net_2770 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2738 net_2768 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2738 net_2739 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2739 net_2738 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2752 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2752 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2745 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2721 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2771 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2733 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2768 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2772 net_2749 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2772 net_2749 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2766 net_2757 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2766 net_2757 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2747 net_2754 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2747 net_2754 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2764 net_2772 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2764 net_2772 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2748 net_2761 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2748 net_2761 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2750 I VSS VSS nch w=3u l=0.09u
M_152 net_2750 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2758 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2758 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2770 net_2768 VSS VSS nch w=3u l=0.09u
M_156 net_2770 net_2768 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2773 net_2774 VSS nch w=20u l=0.09u
M_158 VSS net_2775 net_2773 VSS nch w=10u l=0.09u
M_159 VDD net_2773 net_2774 VDD pch w=30u l=0.09u
M_160 VDD net_2775 net_2773 VDD pch w=10u l=0.09u
M_161 VSS net_2743 net_2776 VSS nch_25od w=0.6u l=0.5u
M_162 net_2775 net_2776 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2777 net_2766 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2778 net_2771 net_2777 VSS nch_25od w=10u l=0.5u
M_165 net_2723 net_2771 net_2765 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2743 net_2775 VSS nch_25od w=5u l=0.5u
M_167 net_2745 net_2771 net_2779 VSS nch_25od w=30u l=0.5u
M_168 net_2780 net_2771 net_2778 VSS nch_25od w=10u l=0.5u
M_169 net_2779 net_2748 net_2780 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2743 net_2776 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2778 net_2771 net_2745 net_2724 pch_25od w=26u l=0.415u
M_172 net_2723 net_2778 net_2765 net_2724 pch_25od w=26u l=0.415u
M_173 VDD net_2743 net_2775 VDD pch_25od w=5u l=0.415u
M_174 net_2724 net_2778 VDDPST net_2724 pch_25od w=24u l=0.415u
M_175 net_2724 net_2771 net_2745 net_2724 pch_25od w=24u l=0.415u
M_176 net_2723 net_2771 net_2745 net_2724 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT08DGZ
.SUBCKT PDT12DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2781 net_2781 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2782 net_2782 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_14 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_15 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_16 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_17 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_18 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_19 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_20 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_21 net_2783 net_2783 rppolywo w=0.4u l=1.3u m=1
X_22 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_23 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_24 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_25 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_26 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_27 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
X_28 net_2784 net_2784 rppolywo w=0.4u l=1.3u m=1
M_29 net_2785 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2786 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2787 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2788 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2789 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2790 net_2782 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_2791 net_2785 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2791 net_2786 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2791 net_2787 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2791 net_2788 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2791 net_2789 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2791 net_2790 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2791 net_2792 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2791 net_2793 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2791 net_2794 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2791 net_2795 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2791 net_2796 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2791 net_2797 VSS nch_25od w=33u l=0.5u
M_47 net_2792 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2793 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2794 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2795 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2796 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2797 net_2781 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_54 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_55 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_56 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_57 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_58 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_59 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_60 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_61 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_62 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_63 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_64 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_65 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_66 PAD net_2784 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_67 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_68 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_69 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_70 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_71 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_72 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_73 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_74 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_75 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_76 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_77 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_78 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_79 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_80 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_81 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_82 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_83 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_84 PAD net_2783 VDDPST net_2784 pch_25od w=16.5u l=0.415u
M_85 VSS net_2798 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2784 net_2784 net_2784 net_2784 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2799 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2800 net_2800 VSS nch_25od w=2.1u l=0.5u
M_89 net_2801 net_2802 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2803 net_2802 net_2801 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2800 net_2802 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2803 net_2802 net_2804 VDDPST pch_25od w=5u l=0.415u
M_93 net_2804 net_2805 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2806 net_2807 net_2781 VDDPST pch_25od w=20u l=0.415u
M_95 net_2806 net_2808 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2781 net_2808 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2807 net_2781 VSS nch_25od w=15u l=0.5u
M_98 net_2809 net_2810 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2811 net_2812 net_2813 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2814 VSS nch_25od w=10u l=0.5u
M_101 net_2815 net_2812 net_2816 VSS nch_25od w=10u l=0.5u
M_102 net_2814 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2814 net_2809 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2814 net_2809 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2816 VSS nch w=10u l=0.09u
M_106 net_2811 net_2810 VSS VSS nch w=10u l=0.09u
M_107 net_2815 I net_2814 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2809 net_2810 net_2813 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2817 net_2818 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2819 net_2812 net_2820 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2821 VSS nch_25od w=10u l=0.5u
M_112 net_2822 net_2812 net_2823 VSS nch_25od w=10u l=0.5u
M_113 net_2821 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2821 net_2817 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2821 net_2817 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2823 VSS nch w=10u l=0.09u
M_117 net_2819 net_2818 VSS VSS nch w=10u l=0.09u
M_118 net_2822 OEN net_2821 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2817 net_2818 net_2820 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2824 net_2825 VDDPST pch_25od w=40u l=0.415u
M_121 net_2825 net_2826 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2827 net_2824 net_2825 VSS nch_25od w=20u l=0.5u
M_123 net_2827 net_2826 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2828 net_2829 VSS nch w=3u l=0.1u
M_125 net_2828 net_2829 VDD VDD pch w=4u l=0.1u
M_126 net_2829 net_2828 net_2828 VDD pch w=4u l=0.1u
M_127 net_2798 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2799 net_2830 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2798 net_2828 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2798 net_2799 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2799 net_2798 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2812 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2812 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2805 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2782 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2831 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2791 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2828 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2832 net_2809 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2832 net_2809 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2826 net_2817 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2826 net_2817 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2807 net_2814 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2807 net_2814 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2824 net_2832 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2824 net_2832 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2808 net_2821 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2808 net_2821 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2810 I VSS VSS nch w=3u l=0.09u
M_152 net_2810 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2818 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2818 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2830 net_2828 VSS VSS nch w=3u l=0.09u
M_156 net_2830 net_2828 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2833 net_2834 VSS nch w=20u l=0.09u
M_158 VSS net_2835 net_2833 VSS nch w=10u l=0.09u
M_159 VDD net_2833 net_2834 VDD pch w=30u l=0.09u
M_160 VDD net_2835 net_2833 VDD pch w=10u l=0.09u
M_161 VSS net_2803 net_2836 VSS nch_25od w=0.6u l=0.5u
M_162 net_2835 net_2836 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2837 net_2826 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2838 net_2831 net_2837 VSS nch_25od w=10u l=0.5u
M_165 net_2783 net_2831 net_2825 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2803 net_2835 VSS nch_25od w=5u l=0.5u
M_167 net_2805 net_2831 net_2839 VSS nch_25od w=30u l=0.5u
M_168 net_2840 net_2831 net_2838 VSS nch_25od w=10u l=0.5u
M_169 net_2839 net_2808 net_2840 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2803 net_2836 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2838 net_2831 net_2805 net_2784 pch_25od w=26u l=0.415u
M_172 net_2783 net_2838 net_2825 net_2784 pch_25od w=26u l=0.415u
M_173 VDD net_2803 net_2835 VDD pch_25od w=5u l=0.415u
M_174 net_2784 net_2838 VDDPST net_2784 pch_25od w=24u l=0.415u
M_175 net_2784 net_2831 net_2805 net_2784 pch_25od w=24u l=0.415u
M_176 net_2783 net_2831 net_2805 net_2784 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT12DGZ
.SUBCKT PDT16DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2841 net_2841 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2841 net_2841 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2841 net_2841 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2841 net_2841 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2842 net_2842 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_14 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_15 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_16 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_17 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_18 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_19 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_20 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_21 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_22 net_2844 net_2844 rppolywo w=0.4u l=1.3u m=1
X_23 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_24 net_2844 net_2844 rppolywo w=0.4u l=1.3u m=1
X_25 net_2844 net_2844 rppolywo w=0.4u l=1.3u m=1
X_26 net_2844 net_2844 rppolywo w=0.4u l=1.3u m=1
X_27 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
X_28 net_2843 net_2843 rppolywo w=0.4u l=1.3u m=1
M_29 net_2845 net_2841 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2846 net_2841 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2847 net_2841 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2848 net_2841 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_2849 net_2845 VSS nch_25od w=33u l=0.5u
M_34 PAD net_2849 net_2846 VSS nch_25od w=33u l=0.5u
M_35 PAD net_2849 net_2847 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2849 net_2848 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2849 net_2850 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2849 net_2851 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2849 net_2852 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2849 net_2853 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2849 net_2854 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2849 net_2855 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2849 net_2856 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2849 net_2857 VSS nch_25od w=33u l=0.5u
M_45 net_2850 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_46 net_2851 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_47 net_2852 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2853 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2854 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2855 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2856 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2857 net_2842 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_54 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_55 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_56 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_57 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_58 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_59 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_60 PAD net_2844 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_61 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_62 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_63 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_64 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_65 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_66 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_67 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_68 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_69 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_70 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_71 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_72 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_73 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_74 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_75 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_76 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_77 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_78 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_79 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_80 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_81 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_82 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_83 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_84 PAD net_2843 VDDPST net_2844 pch_25od w=16.5u l=0.415u
M_85 VSS net_2858 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2844 net_2844 net_2844 net_2844 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2859 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2860 net_2860 VSS nch_25od w=2.1u l=0.5u
M_89 net_2861 net_2862 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2863 net_2862 net_2861 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2860 net_2862 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2863 net_2862 net_2864 VDDPST pch_25od w=5u l=0.415u
M_93 net_2864 net_2865 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2866 net_2867 net_2842 VDDPST pch_25od w=20u l=0.415u
M_95 net_2866 net_2868 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2842 net_2868 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2867 net_2842 VSS nch_25od w=15u l=0.5u
M_98 net_2869 net_2870 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2871 net_2872 net_2873 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2874 VSS nch_25od w=10u l=0.5u
M_101 net_2875 net_2872 net_2876 VSS nch_25od w=10u l=0.5u
M_102 net_2874 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2874 net_2869 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2874 net_2869 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2876 VSS nch w=10u l=0.09u
M_106 net_2871 net_2870 VSS VSS nch w=10u l=0.09u
M_107 net_2875 I net_2874 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2869 net_2870 net_2873 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2877 net_2878 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2879 net_2872 net_2880 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2881 VSS nch_25od w=10u l=0.5u
M_112 net_2882 net_2872 net_2883 VSS nch_25od w=10u l=0.5u
M_113 net_2881 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2881 net_2877 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2881 net_2877 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2883 VSS nch w=10u l=0.09u
M_117 net_2879 net_2878 VSS VSS nch w=10u l=0.09u
M_118 net_2882 OEN net_2881 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2877 net_2878 net_2880 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2884 net_2885 VDDPST pch_25od w=40u l=0.415u
M_121 net_2885 net_2886 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2887 net_2884 net_2885 VSS nch_25od w=20u l=0.5u
M_123 net_2887 net_2886 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2888 net_2889 VSS nch w=3u l=0.1u
M_125 net_2888 net_2889 VDD VDD pch w=4u l=0.1u
M_126 net_2889 net_2888 net_2888 VDD pch w=4u l=0.1u
M_127 net_2858 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2859 net_2890 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2858 net_2888 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2858 net_2859 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2859 net_2858 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2872 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2872 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2865 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2841 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2891 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2849 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2888 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2892 net_2869 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2892 net_2869 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2886 net_2877 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2886 net_2877 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2867 net_2874 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2867 net_2874 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2884 net_2892 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2884 net_2892 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2868 net_2881 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2868 net_2881 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2870 I VSS VSS nch w=3u l=0.09u
M_152 net_2870 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2878 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2878 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2890 net_2888 VSS VSS nch w=3u l=0.09u
M_156 net_2890 net_2888 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2893 net_2894 VSS nch w=20u l=0.09u
M_158 VSS net_2895 net_2893 VSS nch w=10u l=0.09u
M_159 VDD net_2893 net_2894 VDD pch w=30u l=0.09u
M_160 VDD net_2895 net_2893 VDD pch w=10u l=0.09u
M_161 VSS net_2863 net_2896 VSS nch_25od w=0.6u l=0.5u
M_162 net_2895 net_2896 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2897 net_2886 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2898 net_2891 net_2897 VSS nch_25od w=10u l=0.5u
M_165 net_2843 net_2891 net_2885 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2863 net_2895 VSS nch_25od w=5u l=0.5u
M_167 net_2865 net_2891 net_2899 VSS nch_25od w=30u l=0.5u
M_168 net_2900 net_2891 net_2898 VSS nch_25od w=10u l=0.5u
M_169 net_2899 net_2868 net_2900 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2863 net_2896 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2898 net_2891 net_2865 net_2844 pch_25od w=26u l=0.415u
M_172 net_2843 net_2898 net_2885 net_2844 pch_25od w=26u l=0.415u
M_173 VDD net_2863 net_2895 VDD pch_25od w=5u l=0.415u
M_174 net_2844 net_2898 VDDPST net_2844 pch_25od w=24u l=0.415u
M_175 net_2844 net_2891 net_2865 net_2844 pch_25od w=24u l=0.415u
M_176 net_2843 net_2891 net_2865 net_2844 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT16DGZ
.SUBCKT PDT24DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2901 net_2901 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_14 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_15 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_16 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_17 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_18 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_19 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_20 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_21 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_22 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_23 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_24 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_25 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_26 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_27 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
X_28 net_2902 net_2902 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_2903 net_2904 VSS nch_25od w=33u l=0.5u
M_30 PAD net_2903 net_2905 VSS nch_25od w=33u l=0.5u
M_31 PAD net_2903 net_2906 VSS nch_25od w=33u l=0.5u
M_32 PAD net_2903 net_2907 VSS nch_25od w=33u l=0.5u
M_33 PAD net_2903 net_2908 VSS nch_25od w=33u l=0.5u
M_34 PAD net_2903 net_2909 VSS nch_25od w=33u l=0.5u
M_35 PAD net_2903 net_2910 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2903 net_2911 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2903 net_2912 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2903 net_2913 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2903 net_2914 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2903 net_2915 VSS nch_25od w=33u l=0.5u
M_41 net_2904 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_42 net_2905 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_43 net_2906 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_44 net_2907 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_45 net_2908 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_46 net_2909 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_47 net_2910 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2911 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2912 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2913 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2914 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2915 net_2901 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_54 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_55 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_56 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_57 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_58 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_59 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_60 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_61 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_62 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_63 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_64 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_65 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_66 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_67 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_68 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_69 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_70 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_71 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_72 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_73 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_74 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_75 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_76 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_77 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_78 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_79 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_80 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_81 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_82 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_83 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_84 PAD net_2902 VDDPST net_2916 pch_25od w=16.5u l=0.415u
M_85 VSS net_2917 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2916 net_2916 net_2916 net_2916 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2918 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2919 net_2919 VSS nch_25od w=2.1u l=0.5u
M_89 net_2920 net_2921 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2922 net_2921 net_2920 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2919 net_2921 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2922 net_2921 net_2923 VDDPST pch_25od w=5u l=0.415u
M_93 net_2923 net_2924 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2925 net_2926 net_2901 VDDPST pch_25od w=20u l=0.415u
M_95 net_2925 net_2927 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2901 net_2927 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2926 net_2901 VSS nch_25od w=15u l=0.5u
M_98 net_2928 net_2929 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2930 net_2931 net_2932 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2933 VSS nch_25od w=10u l=0.5u
M_101 net_2934 net_2931 net_2935 VSS nch_25od w=10u l=0.5u
M_102 net_2933 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2933 net_2928 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2933 net_2928 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2935 VSS nch w=10u l=0.09u
M_106 net_2930 net_2929 VSS VSS nch w=10u l=0.09u
M_107 net_2934 I net_2933 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2928 net_2929 net_2932 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2936 net_2937 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2938 net_2931 net_2939 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2940 VSS nch_25od w=10u l=0.5u
M_112 net_2941 net_2931 net_2942 VSS nch_25od w=10u l=0.5u
M_113 net_2940 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2940 net_2936 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2940 net_2936 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2942 VSS nch w=10u l=0.09u
M_117 net_2938 net_2937 VSS VSS nch w=10u l=0.09u
M_118 net_2941 OEN net_2940 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2936 net_2937 net_2939 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2943 net_2944 VDDPST pch_25od w=40u l=0.415u
M_121 net_2944 net_2945 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2946 net_2943 net_2944 VSS nch_25od w=20u l=0.5u
M_123 net_2946 net_2945 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2947 net_2948 VSS nch w=3u l=0.1u
M_125 net_2947 net_2948 VDD VDD pch w=4u l=0.1u
M_126 net_2948 net_2947 net_2947 VDD pch w=4u l=0.1u
M_127 net_2917 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2918 net_2949 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2917 net_2947 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2917 net_2918 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2918 net_2917 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2931 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2931 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2924 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2950 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2951 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2903 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2947 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2952 net_2928 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2952 net_2928 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2945 net_2936 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2945 net_2936 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2926 net_2933 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2926 net_2933 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2943 net_2952 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2943 net_2952 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2927 net_2940 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2927 net_2940 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2929 I VSS VSS nch w=3u l=0.09u
M_152 net_2929 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2937 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2937 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2949 net_2947 VSS VSS nch w=3u l=0.09u
M_156 net_2949 net_2947 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2953 net_2954 VSS nch w=20u l=0.09u
M_158 VSS net_2955 net_2953 VSS nch w=10u l=0.09u
M_159 VDD net_2953 net_2954 VDD pch w=30u l=0.09u
M_160 VDD net_2955 net_2953 VDD pch w=10u l=0.09u
M_161 VSS net_2922 net_2956 VSS nch_25od w=0.6u l=0.5u
M_162 net_2955 net_2956 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2957 net_2945 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2958 net_2951 net_2957 VSS nch_25od w=10u l=0.5u
M_165 net_2902 net_2951 net_2944 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2922 net_2955 VSS nch_25od w=5u l=0.5u
M_167 net_2924 net_2951 net_2959 VSS nch_25od w=30u l=0.5u
M_168 net_2960 net_2951 net_2958 VSS nch_25od w=10u l=0.5u
M_169 net_2959 net_2927 net_2960 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2922 net_2956 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2958 net_2951 net_2924 net_2916 pch_25od w=26u l=0.415u
M_172 net_2902 net_2958 net_2944 net_2916 pch_25od w=26u l=0.415u
M_173 VDD net_2922 net_2955 VDD pch_25od w=5u l=0.415u
M_174 net_2916 net_2958 VDDPST net_2916 pch_25od w=24u l=0.415u
M_175 net_2916 net_2951 net_2924 net_2916 pch_25od w=24u l=0.415u
M_176 net_2902 net_2951 net_2924 net_2916 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDT24DGZ
.SUBCKT PDU02DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2962 net_2962 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2962 net_2962 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2961 net_2961 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_14 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_15 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_16 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_17 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_18 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_19 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_20 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_21 net_2964 net_2964 rppolywo w=0.4u l=1.3u m=1
X_22 net_2964 net_2964 rppolywo w=0.4u l=1.3u m=1
X_23 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_24 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_25 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_26 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_27 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
X_28 net_2963 net_2963 rppolywo w=0.4u l=1.3u m=1
M_29 net_2965 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2966 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2967 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2968 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2969 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2970 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2971 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2972 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2973 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2974 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2975 net_2961 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_2976 net_2965 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2976 net_2966 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2976 net_2967 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2976 net_2968 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2976 net_2969 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2976 net_2970 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2976 net_2971 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2976 net_2972 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2976 net_2973 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2976 net_2974 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2976 net_2975 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2976 net_2977 VSS nch_25od w=33u l=0.5u
M_52 net_2977 net_2962 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_54 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_55 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_56 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_57 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_58 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_59 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_60 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_61 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_62 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_63 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_64 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_65 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_66 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_67 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_68 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_69 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_70 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_71 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_72 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_73 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_74 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_75 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_76 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_77 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_78 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_79 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_80 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_81 PAD net_2963 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_82 PAD net_2964 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_83 PAD net_2964 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_84 PAD net_2964 VDDPST net_2963 pch_25od w=16.5u l=0.415u
M_85 VSS net_2978 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2963 net_2963 net_2963 net_2963 pch_25od w=0.5u l=0.9u
M_87 net_2979 net_2980 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_2981 net_2979 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2982 net_2979 net_2981 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2982 net_2979 net_2983 VDDPST pch_25od w=5u l=0.415u
M_93 net_2983 net_2984 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2985 net_2986 net_2962 VDDPST pch_25od w=20u l=0.415u
M_95 net_2985 net_2987 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2962 net_2987 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2986 net_2962 VSS nch_25od w=15u l=0.5u
M_98 net_2988 net_2989 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2990 net_2991 net_2992 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2993 VSS nch_25od w=10u l=0.5u
M_101 net_2994 net_2991 net_2995 VSS nch_25od w=10u l=0.5u
M_102 net_2993 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2993 net_2988 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2993 net_2988 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2995 VSS nch w=10u l=0.09u
M_106 net_2990 net_2989 VSS VSS nch w=10u l=0.09u
M_107 net_2994 I net_2993 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2988 net_2989 net_2992 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2996 net_2997 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2998 net_2991 net_2999 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3000 VSS nch_25od w=10u l=0.5u
M_112 net_3001 net_2991 net_3002 VSS nch_25od w=10u l=0.5u
M_113 net_3000 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3000 net_2996 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3000 net_2996 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3002 VSS nch w=10u l=0.09u
M_117 net_2998 net_2997 VSS VSS nch w=10u l=0.09u
M_118 net_3001 OEN net_3000 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2996 net_2997 net_2999 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3003 net_3004 VDDPST pch_25od w=40u l=0.415u
M_121 net_3004 net_3005 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3006 net_3003 net_3004 VSS nch_25od w=20u l=0.5u
M_123 net_3006 net_3005 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3007 net_3008 VSS nch w=3u l=0.1u
M_125 net_3007 net_3008 VDD VDD pch w=4u l=0.1u
M_126 net_3008 net_3007 net_3007 VDD pch w=4u l=0.1u
M_127 net_2978 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2980 net_3009 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2978 net_3008 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2978 net_2980 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2980 net_2978 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2991 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2991 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2984 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2961 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3010 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2976 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3008 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3011 net_2988 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3011 net_2988 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3005 net_2996 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3005 net_2996 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2986 net_2993 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2986 net_2993 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3003 net_3011 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3003 net_3011 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2987 net_3000 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2987 net_3000 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2989 I VSS VSS nch w=3u l=0.09u
M_152 net_2989 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2997 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2997 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3009 net_3008 VSS VSS nch w=3u l=0.09u
M_156 net_3009 net_3008 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3012 C VSS nch w=20u l=0.09u
M_158 VSS net_3013 net_3012 VSS nch w=10u l=0.09u
M_159 VDD net_3012 C VDD pch w=30u l=0.09u
M_160 VDD net_3013 net_3012 VDD pch w=10u l=0.09u
M_161 VSS net_2982 net_3014 VSS nch_25od w=0.6u l=0.5u
M_162 net_3013 net_3014 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3015 net_3005 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3016 net_3010 net_3015 VSS nch_25od w=10u l=0.5u
M_165 net_2964 net_3010 net_3004 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2982 net_3013 VSS nch_25od w=5u l=0.5u
M_167 net_2984 net_3010 net_2979 VSS nch_25od w=30u l=0.5u
M_168 net_3017 net_3010 net_3016 VSS nch_25od w=10u l=0.5u
M_169 net_2979 net_2987 net_3017 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2982 net_3014 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3016 net_3010 net_2984 net_2963 pch_25od w=26u l=0.415u
M_172 net_2964 net_3016 net_3004 net_2963 pch_25od w=26u l=0.415u
M_173 VDD net_2982 net_3013 VDD pch_25od w=5u l=0.415u
M_174 net_2963 net_3016 VDDPST net_2963 pch_25od w=24u l=0.415u
M_175 net_2963 net_3010 net_2984 net_2963 pch_25od w=24u l=0.415u
M_176 net_2964 net_3010 net_2984 net_2963 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU02DGZ
.SUBCKT PDU02SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3019 net_3019 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3019 net_3019 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3018 net_3018 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_14 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_15 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_16 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_17 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_18 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_19 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_20 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_21 net_3021 net_3021 rppolywo w=0.4u l=1.3u m=1
X_22 net_3021 net_3021 rppolywo w=0.4u l=1.3u m=1
X_23 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_24 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_25 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_26 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_27 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
X_28 net_3020 net_3020 rppolywo w=0.4u l=1.3u m=1
M_29 net_3022 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3023 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3024 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3025 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3026 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3027 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3028 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3029 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3030 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3031 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_39 net_3032 net_3018 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_3033 net_3022 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3033 net_3023 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3033 net_3024 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3033 net_3025 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3033 net_3026 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3033 net_3027 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3033 net_3028 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3033 net_3029 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3033 net_3030 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3033 net_3031 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3033 net_3032 VSS nch_25od w=33u l=0.5u
M_51 PAD net_3033 net_3034 VSS nch_25od w=33u l=0.5u
M_52 net_3034 net_3019 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_54 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_55 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_56 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_57 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_58 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_59 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_60 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_61 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_62 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_63 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_64 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_65 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_66 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_67 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_68 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_69 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_70 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_71 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_72 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_73 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_74 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_75 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_76 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_77 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_78 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_79 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_80 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_81 PAD net_3020 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_82 PAD net_3021 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_83 PAD net_3021 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_84 PAD net_3021 VDDPST net_3020 pch_25od w=16.5u l=0.415u
M_85 VSS net_3035 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3020 net_3020 net_3020 net_3020 pch_25od w=0.5u l=0.9u
M_87 net_3036 net_3037 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3038 net_3039 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3038 net_3036 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3039 net_3036 net_3038 VSS nch_25od w=5u l=0.5u
M_91 net_3040 net_3039 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3039 net_3036 net_3040 VDDPST pch_25od w=5u l=0.415u
M_93 net_3040 net_3041 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3042 net_3043 net_3019 VDDPST pch_25od w=20u l=0.415u
M_95 net_3042 net_3044 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3019 net_3044 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3043 net_3019 VSS nch_25od w=15u l=0.5u
M_98 net_3045 net_3046 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3047 net_3048 net_3049 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3050 VSS nch_25od w=10u l=0.5u
M_101 net_3051 net_3048 net_3052 VSS nch_25od w=10u l=0.5u
M_102 net_3050 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3050 net_3045 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3050 net_3045 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3052 VSS nch w=10u l=0.09u
M_106 net_3047 net_3046 VSS VSS nch w=10u l=0.09u
M_107 net_3051 I net_3050 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3045 net_3046 net_3049 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3053 net_3054 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3055 net_3048 net_3056 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3057 VSS nch_25od w=10u l=0.5u
M_112 net_3058 net_3048 net_3059 VSS nch_25od w=10u l=0.5u
M_113 net_3057 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3057 net_3053 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3057 net_3053 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3059 VSS nch w=10u l=0.09u
M_117 net_3055 net_3054 VSS VSS nch w=10u l=0.09u
M_118 net_3058 OEN net_3057 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3053 net_3054 net_3056 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3060 net_3061 VDDPST pch_25od w=40u l=0.415u
M_121 net_3061 net_3062 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3063 net_3060 net_3061 VSS nch_25od w=20u l=0.5u
M_123 net_3063 net_3062 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3064 net_3065 VSS nch w=3u l=0.1u
M_125 net_3064 net_3065 VDD VDD pch w=4u l=0.1u
M_126 net_3065 net_3064 net_3064 VDD pch w=4u l=0.1u
M_127 net_3035 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3037 net_3066 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3035 net_3065 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3035 net_3037 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3037 net_3035 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3048 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3048 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3041 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3018 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3067 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3033 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3065 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3068 net_3045 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3068 net_3045 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3062 net_3053 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3062 net_3053 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3043 net_3050 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3043 net_3050 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3060 net_3068 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3060 net_3068 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3044 net_3057 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3044 net_3057 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3046 I VSS VSS nch w=3u l=0.09u
M_152 net_3046 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3054 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3054 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3066 net_3065 VSS VSS nch w=3u l=0.09u
M_156 net_3066 net_3065 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3069 C VSS nch w=20u l=0.09u
M_158 VSS net_3070 net_3069 VSS nch w=10u l=0.09u
M_159 VDD net_3069 C VDD pch w=30u l=0.09u
M_160 VDD net_3070 net_3069 VDD pch w=10u l=0.09u
M_161 VSS net_3039 net_3071 VSS nch_25od w=0.6u l=0.5u
M_162 net_3070 net_3071 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3072 net_3062 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3073 net_3067 net_3072 VSS nch_25od w=10u l=0.5u
M_165 net_3021 net_3067 net_3061 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3039 net_3070 VSS nch_25od w=5u l=0.5u
M_167 net_3041 net_3067 net_3036 VSS nch_25od w=30u l=0.5u
M_168 net_3074 net_3067 net_3073 VSS nch_25od w=10u l=0.5u
M_169 net_3036 net_3044 net_3074 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3039 net_3071 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3073 net_3067 net_3041 net_3020 pch_25od w=26u l=0.415u
M_172 net_3021 net_3073 net_3061 net_3020 pch_25od w=26u l=0.415u
M_173 VDD net_3039 net_3070 VDD pch_25od w=5u l=0.415u
M_174 net_3020 net_3073 VDDPST net_3020 pch_25od w=24u l=0.415u
M_175 net_3020 net_3067 net_3041 net_3020 pch_25od w=24u l=0.415u
M_176 net_3021 net_3067 net_3041 net_3020 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU02SDGZ
.SUBCKT PDU04DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3076 net_3076 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3076 net_3076 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3075 net_3075 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_14 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_15 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_16 net_3078 net_3078 rppolywo w=0.4u l=1.3u m=1
X_17 net_3078 net_3078 rppolywo w=0.4u l=1.3u m=1
X_18 net_3078 net_3078 rppolywo w=0.4u l=1.3u m=1
X_19 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_20 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_21 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_22 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_23 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_24 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_25 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_26 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_27 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
X_28 net_3077 net_3077 rppolywo w=0.4u l=1.3u m=1
M_29 net_3079 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3080 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3081 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3082 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3083 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3084 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3085 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3086 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3087 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3088 net_3075 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_3089 net_3079 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3089 net_3080 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3089 net_3081 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3089 net_3082 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3089 net_3083 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3089 net_3084 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3089 net_3085 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3089 net_3086 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3089 net_3087 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3089 net_3088 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3089 net_3090 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3089 net_3091 VSS nch_25od w=33u l=0.5u
M_51 net_3090 net_3076 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3091 net_3076 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_54 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_55 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_56 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_57 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_58 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_59 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_60 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_61 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_62 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_63 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_64 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_65 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_66 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_67 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_68 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_69 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_70 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_71 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_72 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_73 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_74 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_75 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_76 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_77 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_78 PAD net_3077 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_79 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_80 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_81 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_82 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_83 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_84 PAD net_3078 VDDPST net_3077 pch_25od w=16.5u l=0.415u
M_85 VSS net_3092 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3077 net_3077 net_3077 net_3077 pch_25od w=0.5u l=0.9u
M_87 net_3093 net_3094 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3095 net_3093 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3096 net_3093 net_3095 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3096 net_3093 net_3097 VDDPST pch_25od w=5u l=0.415u
M_93 net_3097 net_3098 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3099 net_3100 net_3076 VDDPST pch_25od w=20u l=0.415u
M_95 net_3099 net_3101 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3076 net_3101 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3100 net_3076 VSS nch_25od w=15u l=0.5u
M_98 net_3102 net_3103 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3104 net_3105 net_3106 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3107 VSS nch_25od w=10u l=0.5u
M_101 net_3108 net_3105 net_3109 VSS nch_25od w=10u l=0.5u
M_102 net_3107 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3107 net_3102 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3107 net_3102 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3109 VSS nch w=10u l=0.09u
M_106 net_3104 net_3103 VSS VSS nch w=10u l=0.09u
M_107 net_3108 I net_3107 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3102 net_3103 net_3106 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3110 net_3111 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3112 net_3105 net_3113 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3114 VSS nch_25od w=10u l=0.5u
M_112 net_3115 net_3105 net_3116 VSS nch_25od w=10u l=0.5u
M_113 net_3114 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3114 net_3110 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3114 net_3110 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3116 VSS nch w=10u l=0.09u
M_117 net_3112 net_3111 VSS VSS nch w=10u l=0.09u
M_118 net_3115 OEN net_3114 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3110 net_3111 net_3113 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3117 net_3118 VDDPST pch_25od w=40u l=0.415u
M_121 net_3118 net_3119 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3120 net_3117 net_3118 VSS nch_25od w=20u l=0.5u
M_123 net_3120 net_3119 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3121 net_3122 VSS nch w=3u l=0.1u
M_125 net_3121 net_3122 VDD VDD pch w=4u l=0.1u
M_126 net_3122 net_3121 net_3121 VDD pch w=4u l=0.1u
M_127 net_3092 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3094 net_3123 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3092 net_3122 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3092 net_3094 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3094 net_3092 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3105 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3105 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3098 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3075 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3124 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3089 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3122 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3125 net_3102 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3125 net_3102 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3119 net_3110 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3119 net_3110 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3100 net_3107 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3100 net_3107 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3117 net_3125 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3117 net_3125 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3101 net_3114 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3101 net_3114 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3103 I VSS VSS nch w=3u l=0.09u
M_152 net_3103 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3111 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3111 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3123 net_3122 VSS VSS nch w=3u l=0.09u
M_156 net_3123 net_3122 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3126 C VSS nch w=20u l=0.09u
M_158 VSS net_3127 net_3126 VSS nch w=10u l=0.09u
M_159 VDD net_3126 C VDD pch w=30u l=0.09u
M_160 VDD net_3127 net_3126 VDD pch w=10u l=0.09u
M_161 VSS net_3096 net_3128 VSS nch_25od w=0.6u l=0.5u
M_162 net_3127 net_3128 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3129 net_3119 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3130 net_3124 net_3129 VSS nch_25od w=10u l=0.5u
M_165 net_3078 net_3124 net_3118 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3096 net_3127 VSS nch_25od w=5u l=0.5u
M_167 net_3098 net_3124 net_3093 VSS nch_25od w=30u l=0.5u
M_168 net_3131 net_3124 net_3130 VSS nch_25od w=10u l=0.5u
M_169 net_3093 net_3101 net_3131 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3096 net_3128 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3130 net_3124 net_3098 net_3077 pch_25od w=26u l=0.415u
M_172 net_3078 net_3130 net_3118 net_3077 pch_25od w=26u l=0.415u
M_173 VDD net_3096 net_3127 VDD pch_25od w=5u l=0.415u
M_174 net_3077 net_3130 VDDPST net_3077 pch_25od w=24u l=0.415u
M_175 net_3077 net_3124 net_3098 net_3077 pch_25od w=24u l=0.415u
M_176 net_3078 net_3124 net_3098 net_3077 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU04DGZ
.SUBCKT PDU04SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3133 net_3133 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3133 net_3133 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3132 net_3132 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_14 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_15 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_16 net_3135 net_3135 rppolywo w=0.4u l=1.3u m=1
X_17 net_3135 net_3135 rppolywo w=0.4u l=1.3u m=1
X_18 net_3135 net_3135 rppolywo w=0.4u l=1.3u m=1
X_19 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_20 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_21 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_22 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_23 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_24 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_25 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_26 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_27 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
X_28 net_3134 net_3134 rppolywo w=0.4u l=1.3u m=1
M_29 net_3136 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3137 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3138 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3139 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3140 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3141 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3142 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3143 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3144 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3145 net_3132 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_3146 net_3136 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3146 net_3137 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3146 net_3138 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3146 net_3139 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3146 net_3140 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3146 net_3141 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3146 net_3142 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3146 net_3143 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3146 net_3144 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3146 net_3145 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3146 net_3147 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3146 net_3148 VSS nch_25od w=33u l=0.5u
M_51 net_3147 net_3133 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3148 net_3133 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_54 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_55 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_56 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_57 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_58 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_59 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_60 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_61 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_62 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_63 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_64 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_65 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_66 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_67 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_68 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_69 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_70 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_71 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_72 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_73 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_74 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_75 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_76 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_77 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_78 PAD net_3134 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_79 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_80 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_81 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_82 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_83 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_84 PAD net_3135 VDDPST net_3134 pch_25od w=16.5u l=0.415u
M_85 VSS net_3149 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3134 net_3134 net_3134 net_3134 pch_25od w=0.5u l=0.9u
M_87 net_3150 net_3151 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3152 net_3153 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3152 net_3150 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3153 net_3150 net_3152 VSS nch_25od w=5u l=0.5u
M_91 net_3154 net_3153 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3153 net_3150 net_3154 VDDPST pch_25od w=5u l=0.415u
M_93 net_3154 net_3155 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3156 net_3157 net_3133 VDDPST pch_25od w=20u l=0.415u
M_95 net_3156 net_3158 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3133 net_3158 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3157 net_3133 VSS nch_25od w=15u l=0.5u
M_98 net_3159 net_3160 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3161 net_3162 net_3163 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3164 VSS nch_25od w=10u l=0.5u
M_101 net_3165 net_3162 net_3166 VSS nch_25od w=10u l=0.5u
M_102 net_3164 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3164 net_3159 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3164 net_3159 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3166 VSS nch w=10u l=0.09u
M_106 net_3161 net_3160 VSS VSS nch w=10u l=0.09u
M_107 net_3165 I net_3164 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3159 net_3160 net_3163 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3167 net_3168 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3169 net_3162 net_3170 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3171 VSS nch_25od w=10u l=0.5u
M_112 net_3172 net_3162 net_3173 VSS nch_25od w=10u l=0.5u
M_113 net_3171 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3171 net_3167 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3171 net_3167 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3173 VSS nch w=10u l=0.09u
M_117 net_3169 net_3168 VSS VSS nch w=10u l=0.09u
M_118 net_3172 OEN net_3171 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3167 net_3168 net_3170 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3174 net_3175 VDDPST pch_25od w=40u l=0.415u
M_121 net_3175 net_3176 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3177 net_3174 net_3175 VSS nch_25od w=20u l=0.5u
M_123 net_3177 net_3176 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3178 net_3179 VSS nch w=3u l=0.1u
M_125 net_3178 net_3179 VDD VDD pch w=4u l=0.1u
M_126 net_3179 net_3178 net_3178 VDD pch w=4u l=0.1u
M_127 net_3149 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3151 net_3180 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3149 net_3179 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3149 net_3151 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3151 net_3149 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3162 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3162 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3155 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3132 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3181 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3146 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3179 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3182 net_3159 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3182 net_3159 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3176 net_3167 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3176 net_3167 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3157 net_3164 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3157 net_3164 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3174 net_3182 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3174 net_3182 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3158 net_3171 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3158 net_3171 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3160 I VSS VSS nch w=3u l=0.09u
M_152 net_3160 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3168 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3168 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3180 net_3179 VSS VSS nch w=3u l=0.09u
M_156 net_3180 net_3179 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3183 C VSS nch w=20u l=0.09u
M_158 VSS net_3184 net_3183 VSS nch w=10u l=0.09u
M_159 VDD net_3183 C VDD pch w=30u l=0.09u
M_160 VDD net_3184 net_3183 VDD pch w=10u l=0.09u
M_161 VSS net_3153 net_3185 VSS nch_25od w=0.6u l=0.5u
M_162 net_3184 net_3185 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3186 net_3176 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3187 net_3181 net_3186 VSS nch_25od w=10u l=0.5u
M_165 net_3135 net_3181 net_3175 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3153 net_3184 VSS nch_25od w=5u l=0.5u
M_167 net_3155 net_3181 net_3150 VSS nch_25od w=30u l=0.5u
M_168 net_3188 net_3181 net_3187 VSS nch_25od w=10u l=0.5u
M_169 net_3150 net_3158 net_3188 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3153 net_3185 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3187 net_3181 net_3155 net_3134 pch_25od w=26u l=0.415u
M_172 net_3135 net_3187 net_3175 net_3134 pch_25od w=26u l=0.415u
M_173 VDD net_3153 net_3184 VDD pch_25od w=5u l=0.415u
M_174 net_3134 net_3187 VDDPST net_3134 pch_25od w=24u l=0.415u
M_175 net_3134 net_3181 net_3155 net_3134 pch_25od w=24u l=0.415u
M_176 net_3135 net_3181 net_3155 net_3134 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU04SDGZ
.SUBCKT PDU08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3190 net_3190 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3190 net_3190 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3190 net_3190 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3190 net_3190 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3189 net_3189 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_14 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_15 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_16 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_17 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_18 net_3191 net_3191 rppolywo w=0.4u l=1.3u m=1
X_19 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_20 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_21 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_22 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_23 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_24 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_25 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_26 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_27 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
X_28 net_3192 net_3192 rppolywo w=0.4u l=1.3u m=1
M_29 net_3193 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3194 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3195 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3196 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3197 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3198 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3199 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3200 net_3189 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_3201 net_3193 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3201 net_3194 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3201 net_3195 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3201 net_3196 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3201 net_3197 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3201 net_3198 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3201 net_3199 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3201 net_3200 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3201 net_3202 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3201 net_3203 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3201 net_3204 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3201 net_3205 VSS nch_25od w=33u l=0.5u
M_49 net_3202 net_3190 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3203 net_3190 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3204 net_3190 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3205 net_3190 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_54 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_55 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_56 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_57 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_58 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_59 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_60 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_61 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_62 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_63 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_64 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_65 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_66 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_67 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_68 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_69 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_70 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_71 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_72 PAD net_3192 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_73 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_74 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_75 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_76 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_77 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_78 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_79 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_80 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_81 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_82 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_83 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_84 PAD net_3191 VDDPST net_3192 pch_25od w=16.5u l=0.415u
M_85 VSS net_3206 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3192 net_3192 net_3192 net_3192 pch_25od w=0.5u l=0.9u
M_87 net_3207 net_3208 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3209 net_3207 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3210 net_3207 net_3209 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3210 net_3207 net_3211 VDDPST pch_25od w=5u l=0.415u
M_93 net_3211 net_3212 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3213 net_3214 net_3190 VDDPST pch_25od w=20u l=0.415u
M_95 net_3213 net_3215 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3190 net_3215 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3214 net_3190 VSS nch_25od w=15u l=0.5u
M_98 net_3216 net_3217 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3218 net_3219 net_3220 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3221 VSS nch_25od w=10u l=0.5u
M_101 net_3222 net_3219 net_3223 VSS nch_25od w=10u l=0.5u
M_102 net_3221 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3221 net_3216 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3221 net_3216 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3223 VSS nch w=10u l=0.09u
M_106 net_3218 net_3217 VSS VSS nch w=10u l=0.09u
M_107 net_3222 I net_3221 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3216 net_3217 net_3220 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3224 net_3225 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3226 net_3219 net_3227 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3228 VSS nch_25od w=10u l=0.5u
M_112 net_3229 net_3219 net_3230 VSS nch_25od w=10u l=0.5u
M_113 net_3228 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3228 net_3224 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3228 net_3224 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3230 VSS nch w=10u l=0.09u
M_117 net_3226 net_3225 VSS VSS nch w=10u l=0.09u
M_118 net_3229 OEN net_3228 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3224 net_3225 net_3227 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3231 net_3232 VDDPST pch_25od w=40u l=0.415u
M_121 net_3232 net_3233 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3234 net_3231 net_3232 VSS nch_25od w=20u l=0.5u
M_123 net_3234 net_3233 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3235 net_3236 VSS nch w=3u l=0.1u
M_125 net_3235 net_3236 VDD VDD pch w=4u l=0.1u
M_126 net_3236 net_3235 net_3235 VDD pch w=4u l=0.1u
M_127 net_3206 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3208 net_3237 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3206 net_3236 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3206 net_3208 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3208 net_3206 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3219 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3219 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3212 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3189 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3238 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3201 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3236 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3239 net_3216 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3239 net_3216 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3233 net_3224 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3233 net_3224 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3214 net_3221 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3214 net_3221 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3231 net_3239 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3231 net_3239 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3215 net_3228 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3215 net_3228 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3217 I VSS VSS nch w=3u l=0.09u
M_152 net_3217 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3225 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3225 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3237 net_3236 VSS VSS nch w=3u l=0.09u
M_156 net_3237 net_3236 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3240 C VSS nch w=20u l=0.09u
M_158 VSS net_3241 net_3240 VSS nch w=10u l=0.09u
M_159 VDD net_3240 C VDD pch w=30u l=0.09u
M_160 VDD net_3241 net_3240 VDD pch w=10u l=0.09u
M_161 VSS net_3210 net_3242 VSS nch_25od w=0.6u l=0.5u
M_162 net_3241 net_3242 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3243 net_3233 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3244 net_3238 net_3243 VSS nch_25od w=10u l=0.5u
M_165 net_3191 net_3238 net_3232 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3210 net_3241 VSS nch_25od w=5u l=0.5u
M_167 net_3212 net_3238 net_3207 VSS nch_25od w=30u l=0.5u
M_168 net_3245 net_3238 net_3244 VSS nch_25od w=10u l=0.5u
M_169 net_3207 net_3215 net_3245 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3210 net_3242 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3244 net_3238 net_3212 net_3192 pch_25od w=26u l=0.415u
M_172 net_3191 net_3244 net_3232 net_3192 pch_25od w=26u l=0.415u
M_173 VDD net_3210 net_3241 VDD pch_25od w=5u l=0.415u
M_174 net_3192 net_3244 VDDPST net_3192 pch_25od w=24u l=0.415u
M_175 net_3192 net_3238 net_3212 net_3192 pch_25od w=24u l=0.415u
M_176 net_3191 net_3238 net_3212 net_3192 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU08DGZ
.SUBCKT PDU08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3247 net_3247 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3247 net_3247 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3247 net_3247 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3247 net_3247 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3246 net_3246 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_14 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_15 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_16 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_17 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_18 net_3248 net_3248 rppolywo w=0.4u l=1.3u m=1
X_19 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_20 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_21 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_22 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_23 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_24 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_25 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_26 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_27 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
X_28 net_3249 net_3249 rppolywo w=0.4u l=1.3u m=1
M_29 net_3250 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3251 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3252 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3253 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3254 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3255 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3256 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3257 net_3246 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_3258 net_3250 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3258 net_3251 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3258 net_3252 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3258 net_3253 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3258 net_3254 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3258 net_3255 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3258 net_3256 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3258 net_3257 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3258 net_3259 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3258 net_3260 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3258 net_3261 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3258 net_3262 VSS nch_25od w=33u l=0.5u
M_49 net_3259 net_3247 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3260 net_3247 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3261 net_3247 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3262 net_3247 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_54 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_55 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_56 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_57 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_58 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_59 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_60 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_61 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_62 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_63 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_64 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_65 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_66 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_67 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_68 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_69 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_70 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_71 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_72 PAD net_3249 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_73 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_74 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_75 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_76 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_77 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_78 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_79 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_80 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_81 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_82 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_83 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_84 PAD net_3248 VDDPST net_3249 pch_25od w=16.5u l=0.415u
M_85 VSS net_3263 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3249 net_3249 net_3249 net_3249 pch_25od w=0.5u l=0.9u
M_87 net_3264 net_3265 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3266 net_3267 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3266 net_3264 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3267 net_3264 net_3266 VSS nch_25od w=5u l=0.5u
M_91 net_3268 net_3267 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3267 net_3264 net_3268 VDDPST pch_25od w=5u l=0.415u
M_93 net_3268 net_3269 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3270 net_3271 net_3247 VDDPST pch_25od w=20u l=0.415u
M_95 net_3270 net_3272 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3247 net_3272 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3271 net_3247 VSS nch_25od w=15u l=0.5u
M_98 net_3273 net_3274 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3275 net_3276 net_3277 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3278 VSS nch_25od w=10u l=0.5u
M_101 net_3279 net_3276 net_3280 VSS nch_25od w=10u l=0.5u
M_102 net_3278 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3278 net_3273 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3278 net_3273 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3280 VSS nch w=10u l=0.09u
M_106 net_3275 net_3274 VSS VSS nch w=10u l=0.09u
M_107 net_3279 I net_3278 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3273 net_3274 net_3277 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3281 net_3282 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3283 net_3276 net_3284 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3285 VSS nch_25od w=10u l=0.5u
M_112 net_3286 net_3276 net_3287 VSS nch_25od w=10u l=0.5u
M_113 net_3285 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3285 net_3281 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3285 net_3281 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3287 VSS nch w=10u l=0.09u
M_117 net_3283 net_3282 VSS VSS nch w=10u l=0.09u
M_118 net_3286 OEN net_3285 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3281 net_3282 net_3284 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3288 net_3289 VDDPST pch_25od w=40u l=0.415u
M_121 net_3289 net_3290 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3291 net_3288 net_3289 VSS nch_25od w=20u l=0.5u
M_123 net_3291 net_3290 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3292 net_3293 VSS nch w=3u l=0.1u
M_125 net_3292 net_3293 VDD VDD pch w=4u l=0.1u
M_126 net_3293 net_3292 net_3292 VDD pch w=4u l=0.1u
M_127 net_3263 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3265 net_3294 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3263 net_3293 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3263 net_3265 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3265 net_3263 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3276 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3276 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3269 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3246 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3295 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3258 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3293 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3296 net_3273 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3296 net_3273 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3290 net_3281 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3290 net_3281 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3271 net_3278 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3271 net_3278 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3288 net_3296 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3288 net_3296 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3272 net_3285 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3272 net_3285 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3274 I VSS VSS nch w=3u l=0.09u
M_152 net_3274 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3282 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3282 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3294 net_3293 VSS VSS nch w=3u l=0.09u
M_156 net_3294 net_3293 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3297 C VSS nch w=20u l=0.09u
M_158 VSS net_3298 net_3297 VSS nch w=10u l=0.09u
M_159 VDD net_3297 C VDD pch w=30u l=0.09u
M_160 VDD net_3298 net_3297 VDD pch w=10u l=0.09u
M_161 VSS net_3267 net_3299 VSS nch_25od w=0.6u l=0.5u
M_162 net_3298 net_3299 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3300 net_3290 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3301 net_3295 net_3300 VSS nch_25od w=10u l=0.5u
M_165 net_3248 net_3295 net_3289 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3267 net_3298 VSS nch_25od w=5u l=0.5u
M_167 net_3269 net_3295 net_3264 VSS nch_25od w=30u l=0.5u
M_168 net_3302 net_3295 net_3301 VSS nch_25od w=10u l=0.5u
M_169 net_3264 net_3272 net_3302 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3267 net_3299 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3301 net_3295 net_3269 net_3249 pch_25od w=26u l=0.415u
M_172 net_3248 net_3301 net_3289 net_3249 pch_25od w=26u l=0.415u
M_173 VDD net_3267 net_3298 VDD pch_25od w=5u l=0.415u
M_174 net_3249 net_3301 VDDPST net_3249 pch_25od w=24u l=0.415u
M_175 net_3249 net_3295 net_3269 net_3249 pch_25od w=24u l=0.415u
M_176 net_3248 net_3295 net_3269 net_3249 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU08SDGZ
.SUBCKT PDU12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3303 net_3303 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3304 net_3304 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_14 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_15 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_16 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_17 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_18 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_19 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_20 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_21 net_3305 net_3305 rppolywo w=0.4u l=1.3u m=1
X_22 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_23 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_24 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_25 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_26 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_27 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
X_28 net_3306 net_3306 rppolywo w=0.4u l=1.3u m=1
M_29 net_3307 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3308 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3309 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3310 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3311 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3312 net_3304 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_3313 net_3307 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3313 net_3308 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3313 net_3309 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3313 net_3310 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3313 net_3311 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3313 net_3312 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3313 net_3314 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3313 net_3315 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3313 net_3316 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3313 net_3317 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3313 net_3318 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3313 net_3319 VSS nch_25od w=33u l=0.5u
M_47 net_3314 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3315 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3316 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3317 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3318 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3319 net_3303 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_54 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_55 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_56 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_57 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_58 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_59 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_60 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_61 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_62 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_63 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_64 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_65 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_66 PAD net_3306 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_67 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_68 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_69 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_70 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_71 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_72 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_73 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_74 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_75 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_76 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_77 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_78 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_79 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_80 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_81 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_82 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_83 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_84 PAD net_3305 VDDPST net_3306 pch_25od w=16.5u l=0.415u
M_85 VSS net_3320 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3306 net_3306 net_3306 net_3306 pch_25od w=0.5u l=0.9u
M_87 net_3321 net_3322 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3323 net_3321 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3324 net_3321 net_3323 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3324 net_3321 net_3325 VDDPST pch_25od w=5u l=0.415u
M_93 net_3325 net_3326 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3327 net_3328 net_3303 VDDPST pch_25od w=20u l=0.415u
M_95 net_3327 net_3329 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3303 net_3329 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3328 net_3303 VSS nch_25od w=15u l=0.5u
M_98 net_3330 net_3331 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3332 net_3333 net_3334 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3335 VSS nch_25od w=10u l=0.5u
M_101 net_3336 net_3333 net_3337 VSS nch_25od w=10u l=0.5u
M_102 net_3335 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3335 net_3330 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3335 net_3330 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3337 VSS nch w=10u l=0.09u
M_106 net_3332 net_3331 VSS VSS nch w=10u l=0.09u
M_107 net_3336 I net_3335 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3330 net_3331 net_3334 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3338 net_3339 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3340 net_3333 net_3341 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3342 VSS nch_25od w=10u l=0.5u
M_112 net_3343 net_3333 net_3344 VSS nch_25od w=10u l=0.5u
M_113 net_3342 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3342 net_3338 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3342 net_3338 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3344 VSS nch w=10u l=0.09u
M_117 net_3340 net_3339 VSS VSS nch w=10u l=0.09u
M_118 net_3343 OEN net_3342 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3338 net_3339 net_3341 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3345 net_3346 VDDPST pch_25od w=40u l=0.415u
M_121 net_3346 net_3347 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3348 net_3345 net_3346 VSS nch_25od w=20u l=0.5u
M_123 net_3348 net_3347 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3349 net_3350 VSS nch w=3u l=0.1u
M_125 net_3349 net_3350 VDD VDD pch w=4u l=0.1u
M_126 net_3350 net_3349 net_3349 VDD pch w=4u l=0.1u
M_127 net_3320 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3322 net_3351 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3320 net_3350 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3320 net_3322 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3322 net_3320 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3333 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3333 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3326 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3304 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3352 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3313 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3350 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3353 net_3330 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3353 net_3330 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3347 net_3338 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3347 net_3338 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3328 net_3335 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3328 net_3335 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3345 net_3353 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3345 net_3353 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3329 net_3342 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3329 net_3342 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3331 I VSS VSS nch w=3u l=0.09u
M_152 net_3331 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3339 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3339 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3351 net_3350 VSS VSS nch w=3u l=0.09u
M_156 net_3351 net_3350 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3354 C VSS nch w=20u l=0.09u
M_158 VSS net_3355 net_3354 VSS nch w=10u l=0.09u
M_159 VDD net_3354 C VDD pch w=30u l=0.09u
M_160 VDD net_3355 net_3354 VDD pch w=10u l=0.09u
M_161 VSS net_3324 net_3356 VSS nch_25od w=0.6u l=0.5u
M_162 net_3355 net_3356 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3357 net_3347 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3358 net_3352 net_3357 VSS nch_25od w=10u l=0.5u
M_165 net_3305 net_3352 net_3346 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3324 net_3355 VSS nch_25od w=5u l=0.5u
M_167 net_3326 net_3352 net_3321 VSS nch_25od w=30u l=0.5u
M_168 net_3359 net_3352 net_3358 VSS nch_25od w=10u l=0.5u
M_169 net_3321 net_3329 net_3359 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3324 net_3356 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3358 net_3352 net_3326 net_3306 pch_25od w=26u l=0.415u
M_172 net_3305 net_3358 net_3346 net_3306 pch_25od w=26u l=0.415u
M_173 VDD net_3324 net_3355 VDD pch_25od w=5u l=0.415u
M_174 net_3306 net_3358 VDDPST net_3306 pch_25od w=24u l=0.415u
M_175 net_3306 net_3352 net_3326 net_3306 pch_25od w=24u l=0.415u
M_176 net_3305 net_3352 net_3326 net_3306 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU12DGZ
.SUBCKT PDU12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3360 net_3360 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3361 net_3361 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_14 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_15 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_16 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_17 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_18 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_19 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_20 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_21 net_3362 net_3362 rppolywo w=0.4u l=1.3u m=1
X_22 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_23 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_24 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_25 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_26 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_27 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
X_28 net_3363 net_3363 rppolywo w=0.4u l=1.3u m=1
M_29 net_3364 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3365 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3366 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3367 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3368 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3369 net_3361 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_3370 net_3364 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3370 net_3365 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3370 net_3366 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3370 net_3367 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3370 net_3368 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3370 net_3369 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3370 net_3371 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3370 net_3372 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3370 net_3373 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3370 net_3374 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3370 net_3375 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3370 net_3376 VSS nch_25od w=33u l=0.5u
M_47 net_3371 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3372 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3373 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3374 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3375 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3376 net_3360 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_54 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_55 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_56 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_57 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_58 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_59 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_60 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_61 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_62 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_63 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_64 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_65 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_66 PAD net_3363 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_67 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_68 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_69 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_70 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_71 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_72 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_73 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_74 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_75 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_76 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_77 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_78 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_79 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_80 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_81 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_82 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_83 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_84 PAD net_3362 VDDPST net_3363 pch_25od w=16.5u l=0.415u
M_85 VSS net_3377 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3363 net_3363 net_3363 net_3363 pch_25od w=0.5u l=0.9u
M_87 net_3378 net_3379 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3380 net_3381 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3380 net_3378 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3381 net_3378 net_3380 VSS nch_25od w=5u l=0.5u
M_91 net_3382 net_3381 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3381 net_3378 net_3382 VDDPST pch_25od w=5u l=0.415u
M_93 net_3382 net_3383 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3384 net_3385 net_3360 VDDPST pch_25od w=20u l=0.415u
M_95 net_3384 net_3386 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3360 net_3386 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3385 net_3360 VSS nch_25od w=15u l=0.5u
M_98 net_3387 net_3388 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3389 net_3390 net_3391 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3392 VSS nch_25od w=10u l=0.5u
M_101 net_3393 net_3390 net_3394 VSS nch_25od w=10u l=0.5u
M_102 net_3392 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3392 net_3387 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3392 net_3387 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3394 VSS nch w=10u l=0.09u
M_106 net_3389 net_3388 VSS VSS nch w=10u l=0.09u
M_107 net_3393 I net_3392 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3387 net_3388 net_3391 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3395 net_3396 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3397 net_3390 net_3398 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3399 VSS nch_25od w=10u l=0.5u
M_112 net_3400 net_3390 net_3401 VSS nch_25od w=10u l=0.5u
M_113 net_3399 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3399 net_3395 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3399 net_3395 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3401 VSS nch w=10u l=0.09u
M_117 net_3397 net_3396 VSS VSS nch w=10u l=0.09u
M_118 net_3400 OEN net_3399 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3395 net_3396 net_3398 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3402 net_3403 VDDPST pch_25od w=40u l=0.415u
M_121 net_3403 net_3404 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3405 net_3402 net_3403 VSS nch_25od w=20u l=0.5u
M_123 net_3405 net_3404 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3406 net_3407 VSS nch w=3u l=0.1u
M_125 net_3406 net_3407 VDD VDD pch w=4u l=0.1u
M_126 net_3407 net_3406 net_3406 VDD pch w=4u l=0.1u
M_127 net_3377 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3379 net_3408 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3377 net_3407 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3377 net_3379 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3379 net_3377 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3390 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3390 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3383 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3361 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3409 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3370 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3407 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3410 net_3387 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3410 net_3387 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3404 net_3395 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3404 net_3395 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3385 net_3392 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3385 net_3392 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3402 net_3410 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3402 net_3410 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3386 net_3399 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3386 net_3399 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3388 I VSS VSS nch w=3u l=0.09u
M_152 net_3388 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3396 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3396 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3408 net_3407 VSS VSS nch w=3u l=0.09u
M_156 net_3408 net_3407 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3411 C VSS nch w=20u l=0.09u
M_158 VSS net_3412 net_3411 VSS nch w=10u l=0.09u
M_159 VDD net_3411 C VDD pch w=30u l=0.09u
M_160 VDD net_3412 net_3411 VDD pch w=10u l=0.09u
M_161 VSS net_3381 net_3413 VSS nch_25od w=0.6u l=0.5u
M_162 net_3412 net_3413 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3414 net_3404 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3415 net_3409 net_3414 VSS nch_25od w=10u l=0.5u
M_165 net_3362 net_3409 net_3403 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3381 net_3412 VSS nch_25od w=5u l=0.5u
M_167 net_3383 net_3409 net_3378 VSS nch_25od w=30u l=0.5u
M_168 net_3416 net_3409 net_3415 VSS nch_25od w=10u l=0.5u
M_169 net_3378 net_3386 net_3416 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3381 net_3413 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3415 net_3409 net_3383 net_3363 pch_25od w=26u l=0.415u
M_172 net_3362 net_3415 net_3403 net_3363 pch_25od w=26u l=0.415u
M_173 VDD net_3381 net_3412 VDD pch_25od w=5u l=0.415u
M_174 net_3363 net_3415 VDDPST net_3363 pch_25od w=24u l=0.415u
M_175 net_3363 net_3409 net_3383 net_3363 pch_25od w=24u l=0.415u
M_176 net_3362 net_3409 net_3383 net_3363 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU12SDGZ
.SUBCKT PDU16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3417 net_3417 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3417 net_3417 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3417 net_3417 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3417 net_3417 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3418 net_3418 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_14 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_15 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_16 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_17 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_18 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_19 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_20 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_21 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_22 net_3420 net_3420 rppolywo w=0.4u l=1.3u m=1
X_23 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_24 net_3420 net_3420 rppolywo w=0.4u l=1.3u m=1
X_25 net_3420 net_3420 rppolywo w=0.4u l=1.3u m=1
X_26 net_3420 net_3420 rppolywo w=0.4u l=1.3u m=1
X_27 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
X_28 net_3419 net_3419 rppolywo w=0.4u l=1.3u m=1
M_29 net_3421 net_3417 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3422 net_3417 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3423 net_3417 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3424 net_3417 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_3425 net_3421 VSS nch_25od w=33u l=0.5u
M_34 PAD net_3425 net_3422 VSS nch_25od w=33u l=0.5u
M_35 PAD net_3425 net_3423 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3425 net_3424 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3425 net_3426 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3425 net_3427 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3425 net_3428 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3425 net_3429 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3425 net_3430 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3425 net_3431 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3425 net_3432 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3425 net_3433 VSS nch_25od w=33u l=0.5u
M_45 net_3426 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_46 net_3427 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_47 net_3428 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3429 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3430 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3431 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3432 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3433 net_3418 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_54 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_55 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_56 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_57 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_58 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_59 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_60 PAD net_3420 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_61 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_62 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_63 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_64 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_65 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_66 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_67 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_68 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_69 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_70 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_71 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_72 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_73 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_74 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_75 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_76 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_77 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_78 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_79 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_80 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_81 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_82 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_83 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_84 PAD net_3419 VDDPST net_3420 pch_25od w=16.5u l=0.415u
M_85 VSS net_3434 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3420 net_3420 net_3420 net_3420 pch_25od w=0.5u l=0.9u
M_87 net_3435 net_3436 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3437 net_3435 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3438 net_3435 net_3437 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3438 net_3435 net_3439 VDDPST pch_25od w=5u l=0.415u
M_93 net_3439 net_3440 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3441 net_3442 net_3418 VDDPST pch_25od w=20u l=0.415u
M_95 net_3441 net_3443 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3418 net_3443 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3442 net_3418 VSS nch_25od w=15u l=0.5u
M_98 net_3444 net_3445 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3446 net_3447 net_3448 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3449 VSS nch_25od w=10u l=0.5u
M_101 net_3450 net_3447 net_3451 VSS nch_25od w=10u l=0.5u
M_102 net_3449 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3449 net_3444 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3449 net_3444 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3451 VSS nch w=10u l=0.09u
M_106 net_3446 net_3445 VSS VSS nch w=10u l=0.09u
M_107 net_3450 I net_3449 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3444 net_3445 net_3448 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3452 net_3453 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3454 net_3447 net_3455 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3456 VSS nch_25od w=10u l=0.5u
M_112 net_3457 net_3447 net_3458 VSS nch_25od w=10u l=0.5u
M_113 net_3456 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3456 net_3452 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3456 net_3452 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3458 VSS nch w=10u l=0.09u
M_117 net_3454 net_3453 VSS VSS nch w=10u l=0.09u
M_118 net_3457 OEN net_3456 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3452 net_3453 net_3455 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3459 net_3460 VDDPST pch_25od w=40u l=0.415u
M_121 net_3460 net_3461 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3462 net_3459 net_3460 VSS nch_25od w=20u l=0.5u
M_123 net_3462 net_3461 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3463 net_3464 VSS nch w=3u l=0.1u
M_125 net_3463 net_3464 VDD VDD pch w=4u l=0.1u
M_126 net_3464 net_3463 net_3463 VDD pch w=4u l=0.1u
M_127 net_3434 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3436 net_3465 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3434 net_3464 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3434 net_3436 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3436 net_3434 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3447 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3447 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3440 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3417 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3466 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3425 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3464 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3467 net_3444 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3467 net_3444 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3461 net_3452 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3461 net_3452 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3442 net_3449 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3442 net_3449 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3459 net_3467 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3459 net_3467 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3443 net_3456 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3443 net_3456 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3445 I VSS VSS nch w=3u l=0.09u
M_152 net_3445 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3453 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3453 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3465 net_3464 VSS VSS nch w=3u l=0.09u
M_156 net_3465 net_3464 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3468 C VSS nch w=20u l=0.09u
M_158 VSS net_3469 net_3468 VSS nch w=10u l=0.09u
M_159 VDD net_3468 C VDD pch w=30u l=0.09u
M_160 VDD net_3469 net_3468 VDD pch w=10u l=0.09u
M_161 VSS net_3438 net_3470 VSS nch_25od w=0.6u l=0.5u
M_162 net_3469 net_3470 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3471 net_3461 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3472 net_3466 net_3471 VSS nch_25od w=10u l=0.5u
M_165 net_3419 net_3466 net_3460 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3438 net_3469 VSS nch_25od w=5u l=0.5u
M_167 net_3440 net_3466 net_3435 VSS nch_25od w=30u l=0.5u
M_168 net_3473 net_3466 net_3472 VSS nch_25od w=10u l=0.5u
M_169 net_3435 net_3443 net_3473 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3438 net_3470 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3472 net_3466 net_3440 net_3420 pch_25od w=26u l=0.415u
M_172 net_3419 net_3472 net_3460 net_3420 pch_25od w=26u l=0.415u
M_173 VDD net_3438 net_3469 VDD pch_25od w=5u l=0.415u
M_174 net_3420 net_3472 VDDPST net_3420 pch_25od w=24u l=0.415u
M_175 net_3420 net_3466 net_3440 net_3420 pch_25od w=24u l=0.415u
M_176 net_3419 net_3466 net_3440 net_3420 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU16DGZ
.SUBCKT PDU16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3474 net_3474 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3474 net_3474 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3474 net_3474 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3474 net_3474 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3475 net_3475 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_14 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_15 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_16 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_17 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_18 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_19 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_20 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_21 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_22 net_3477 net_3477 rppolywo w=0.4u l=1.3u m=1
X_23 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_24 net_3477 net_3477 rppolywo w=0.4u l=1.3u m=1
X_25 net_3477 net_3477 rppolywo w=0.4u l=1.3u m=1
X_26 net_3477 net_3477 rppolywo w=0.4u l=1.3u m=1
X_27 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
X_28 net_3476 net_3476 rppolywo w=0.4u l=1.3u m=1
M_29 net_3478 net_3474 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3479 net_3474 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3480 net_3474 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3481 net_3474 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_3482 net_3478 VSS nch_25od w=33u l=0.5u
M_34 PAD net_3482 net_3479 VSS nch_25od w=33u l=0.5u
M_35 PAD net_3482 net_3480 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3482 net_3481 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3482 net_3483 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3482 net_3484 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3482 net_3485 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3482 net_3486 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3482 net_3487 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3482 net_3488 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3482 net_3489 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3482 net_3490 VSS nch_25od w=33u l=0.5u
M_45 net_3483 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_46 net_3484 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_47 net_3485 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3486 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3487 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3488 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3489 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3490 net_3475 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_54 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_55 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_56 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_57 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_58 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_59 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_60 PAD net_3477 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_61 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_62 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_63 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_64 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_65 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_66 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_67 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_68 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_69 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_70 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_71 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_72 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_73 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_74 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_75 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_76 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_77 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_78 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_79 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_80 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_81 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_82 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_83 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_84 PAD net_3476 VDDPST net_3477 pch_25od w=16.5u l=0.415u
M_85 VSS net_3491 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3477 net_3477 net_3477 net_3477 pch_25od w=0.5u l=0.9u
M_87 net_3492 net_3493 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3494 net_3495 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3494 net_3492 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3495 net_3492 net_3494 VSS nch_25od w=5u l=0.5u
M_91 net_3496 net_3495 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3495 net_3492 net_3496 VDDPST pch_25od w=5u l=0.415u
M_93 net_3496 net_3497 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3498 net_3499 net_3475 VDDPST pch_25od w=20u l=0.415u
M_95 net_3498 net_3500 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3475 net_3500 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3499 net_3475 VSS nch_25od w=15u l=0.5u
M_98 net_3501 net_3502 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3503 net_3504 net_3505 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3506 VSS nch_25od w=10u l=0.5u
M_101 net_3507 net_3504 net_3508 VSS nch_25od w=10u l=0.5u
M_102 net_3506 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3506 net_3501 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3506 net_3501 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3508 VSS nch w=10u l=0.09u
M_106 net_3503 net_3502 VSS VSS nch w=10u l=0.09u
M_107 net_3507 I net_3506 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3501 net_3502 net_3505 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3509 net_3510 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3511 net_3504 net_3512 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3513 VSS nch_25od w=10u l=0.5u
M_112 net_3514 net_3504 net_3515 VSS nch_25od w=10u l=0.5u
M_113 net_3513 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3513 net_3509 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3513 net_3509 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3515 VSS nch w=10u l=0.09u
M_117 net_3511 net_3510 VSS VSS nch w=10u l=0.09u
M_118 net_3514 OEN net_3513 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3509 net_3510 net_3512 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3516 net_3517 VDDPST pch_25od w=40u l=0.415u
M_121 net_3517 net_3518 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3519 net_3516 net_3517 VSS nch_25od w=20u l=0.5u
M_123 net_3519 net_3518 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3520 net_3521 VSS nch w=3u l=0.1u
M_125 net_3520 net_3521 VDD VDD pch w=4u l=0.1u
M_126 net_3521 net_3520 net_3520 VDD pch w=4u l=0.1u
M_127 net_3491 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3493 net_3522 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3491 net_3521 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3491 net_3493 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3493 net_3491 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3504 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3504 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3497 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3474 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3523 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3482 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3521 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3524 net_3501 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3524 net_3501 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3518 net_3509 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3518 net_3509 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3499 net_3506 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3499 net_3506 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3516 net_3524 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3516 net_3524 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3500 net_3513 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3500 net_3513 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3502 I VSS VSS nch w=3u l=0.09u
M_152 net_3502 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3510 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3510 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3522 net_3521 VSS VSS nch w=3u l=0.09u
M_156 net_3522 net_3521 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3525 C VSS nch w=20u l=0.09u
M_158 VSS net_3526 net_3525 VSS nch w=10u l=0.09u
M_159 VDD net_3525 C VDD pch w=30u l=0.09u
M_160 VDD net_3526 net_3525 VDD pch w=10u l=0.09u
M_161 VSS net_3495 net_3527 VSS nch_25od w=0.6u l=0.5u
M_162 net_3526 net_3527 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3528 net_3518 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3529 net_3523 net_3528 VSS nch_25od w=10u l=0.5u
M_165 net_3476 net_3523 net_3517 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3495 net_3526 VSS nch_25od w=5u l=0.5u
M_167 net_3497 net_3523 net_3492 VSS nch_25od w=30u l=0.5u
M_168 net_3530 net_3523 net_3529 VSS nch_25od w=10u l=0.5u
M_169 net_3492 net_3500 net_3530 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3495 net_3527 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3529 net_3523 net_3497 net_3477 pch_25od w=26u l=0.415u
M_172 net_3476 net_3529 net_3517 net_3477 pch_25od w=26u l=0.415u
M_173 VDD net_3495 net_3526 VDD pch_25od w=5u l=0.415u
M_174 net_3477 net_3529 VDDPST net_3477 pch_25od w=24u l=0.415u
M_175 net_3477 net_3523 net_3497 net_3477 pch_25od w=24u l=0.415u
M_176 net_3476 net_3523 net_3497 net_3477 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU16SDGZ
.SUBCKT PDU24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3531 net_3531 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_14 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_15 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_16 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_17 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_18 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_19 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_20 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_21 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_22 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_23 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_24 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_25 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_26 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_27 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
X_28 net_3532 net_3532 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_3533 net_3534 VSS nch_25od w=33u l=0.5u
M_30 PAD net_3533 net_3535 VSS nch_25od w=33u l=0.5u
M_31 PAD net_3533 net_3536 VSS nch_25od w=33u l=0.5u
M_32 PAD net_3533 net_3537 VSS nch_25od w=33u l=0.5u
M_33 PAD net_3533 net_3538 VSS nch_25od w=33u l=0.5u
M_34 PAD net_3533 net_3539 VSS nch_25od w=33u l=0.5u
M_35 PAD net_3533 net_3540 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3533 net_3541 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3533 net_3542 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3533 net_3543 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3533 net_3544 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3533 net_3545 VSS nch_25od w=33u l=0.5u
M_41 net_3534 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_42 net_3535 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_43 net_3536 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_44 net_3537 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_45 net_3538 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_46 net_3539 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_47 net_3540 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3541 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3542 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3543 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3544 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3545 net_3531 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_54 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_55 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_56 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_57 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_58 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_59 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_60 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_61 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_62 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_63 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_64 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_65 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_66 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_67 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_68 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_69 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_70 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_71 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_72 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_73 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_74 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_75 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_76 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_77 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_78 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_79 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_80 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_81 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_82 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_83 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_84 PAD net_3532 VDDPST net_3546 pch_25od w=16.5u l=0.415u
M_85 VSS net_3547 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3546 net_3546 net_3546 net_3546 pch_25od w=0.5u l=0.9u
M_87 net_3548 net_3549 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3550 net_3548 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3551 net_3548 net_3550 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3551 net_3548 net_3552 VDDPST pch_25od w=5u l=0.415u
M_93 net_3552 net_3553 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3554 net_3555 net_3531 VDDPST pch_25od w=20u l=0.415u
M_95 net_3554 net_3556 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3531 net_3556 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3555 net_3531 VSS nch_25od w=15u l=0.5u
M_98 net_3557 net_3558 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3559 net_3560 net_3561 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3562 VSS nch_25od w=10u l=0.5u
M_101 net_3563 net_3560 net_3564 VSS nch_25od w=10u l=0.5u
M_102 net_3562 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3562 net_3557 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3562 net_3557 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3564 VSS nch w=10u l=0.09u
M_106 net_3559 net_3558 VSS VSS nch w=10u l=0.09u
M_107 net_3563 I net_3562 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3557 net_3558 net_3561 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3565 net_3566 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3567 net_3560 net_3568 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3569 VSS nch_25od w=10u l=0.5u
M_112 net_3570 net_3560 net_3571 VSS nch_25od w=10u l=0.5u
M_113 net_3569 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3569 net_3565 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3569 net_3565 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3571 VSS nch w=10u l=0.09u
M_117 net_3567 net_3566 VSS VSS nch w=10u l=0.09u
M_118 net_3570 OEN net_3569 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3565 net_3566 net_3568 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3572 net_3573 VDDPST pch_25od w=40u l=0.415u
M_121 net_3573 net_3574 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3575 net_3572 net_3573 VSS nch_25od w=20u l=0.5u
M_123 net_3575 net_3574 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3576 net_3577 VSS nch w=3u l=0.1u
M_125 net_3576 net_3577 VDD VDD pch w=4u l=0.1u
M_126 net_3577 net_3576 net_3576 VDD pch w=4u l=0.1u
M_127 net_3547 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3549 net_3578 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3547 net_3577 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3547 net_3549 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3549 net_3547 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3560 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3560 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3553 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3579 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3580 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3533 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3577 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3581 net_3557 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3581 net_3557 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3574 net_3565 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3574 net_3565 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3555 net_3562 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3555 net_3562 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3572 net_3581 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3572 net_3581 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3556 net_3569 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3556 net_3569 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3558 I VSS VSS nch w=3u l=0.09u
M_152 net_3558 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3566 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3566 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3578 net_3577 VSS VSS nch w=3u l=0.09u
M_156 net_3578 net_3577 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3582 C VSS nch w=20u l=0.09u
M_158 VSS net_3583 net_3582 VSS nch w=10u l=0.09u
M_159 VDD net_3582 C VDD pch w=30u l=0.09u
M_160 VDD net_3583 net_3582 VDD pch w=10u l=0.09u
M_161 VSS net_3551 net_3584 VSS nch_25od w=0.6u l=0.5u
M_162 net_3583 net_3584 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3585 net_3574 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3586 net_3580 net_3585 VSS nch_25od w=10u l=0.5u
M_165 net_3532 net_3580 net_3573 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3551 net_3583 VSS nch_25od w=5u l=0.5u
M_167 net_3553 net_3580 net_3548 VSS nch_25od w=30u l=0.5u
M_168 net_3587 net_3580 net_3586 VSS nch_25od w=10u l=0.5u
M_169 net_3548 net_3556 net_3587 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3551 net_3584 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3586 net_3580 net_3553 net_3546 pch_25od w=26u l=0.415u
M_172 net_3532 net_3586 net_3573 net_3546 pch_25od w=26u l=0.415u
M_173 VDD net_3551 net_3583 VDD pch_25od w=5u l=0.415u
M_174 net_3546 net_3586 VDDPST net_3546 pch_25od w=24u l=0.415u
M_175 net_3546 net_3580 net_3553 net_3546 pch_25od w=24u l=0.415u
M_176 net_3532 net_3580 net_3553 net_3546 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU24DGZ
.SUBCKT PDU24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3588 net_3588 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_14 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_15 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_16 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_17 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_18 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_19 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_20 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_21 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_22 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_23 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_24 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_25 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_26 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_27 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
X_28 net_3589 net_3589 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_3590 net_3591 VSS nch_25od w=33u l=0.5u
M_30 PAD net_3590 net_3592 VSS nch_25od w=33u l=0.5u
M_31 PAD net_3590 net_3593 VSS nch_25od w=33u l=0.5u
M_32 PAD net_3590 net_3594 VSS nch_25od w=33u l=0.5u
M_33 PAD net_3590 net_3595 VSS nch_25od w=33u l=0.5u
M_34 PAD net_3590 net_3596 VSS nch_25od w=33u l=0.5u
M_35 PAD net_3590 net_3597 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3590 net_3598 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3590 net_3599 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3590 net_3600 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3590 net_3601 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3590 net_3602 VSS nch_25od w=33u l=0.5u
M_41 net_3591 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_42 net_3592 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_43 net_3593 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_44 net_3594 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_45 net_3595 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_46 net_3596 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_47 net_3597 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3598 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3599 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3600 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3601 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3602 net_3588 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_54 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_55 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_56 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_57 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_58 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_59 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_60 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_61 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_62 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_63 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_64 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_65 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_66 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_67 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_68 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_69 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_70 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_71 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_72 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_73 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_74 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_75 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_76 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_77 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_78 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_79 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_80 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_81 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_82 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_83 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_84 PAD net_3589 VDDPST net_3603 pch_25od w=16.5u l=0.415u
M_85 VSS net_3604 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3603 net_3603 net_3603 net_3603 pch_25od w=0.5u l=0.9u
M_87 net_3605 net_3606 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3607 net_3608 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3607 net_3605 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3608 net_3605 net_3607 VSS nch_25od w=5u l=0.5u
M_91 net_3609 net_3608 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3608 net_3605 net_3609 VDDPST pch_25od w=5u l=0.415u
M_93 net_3609 net_3610 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3611 net_3612 net_3588 VDDPST pch_25od w=20u l=0.415u
M_95 net_3611 net_3613 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3588 net_3613 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3612 net_3588 VSS nch_25od w=15u l=0.5u
M_98 net_3614 net_3615 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3616 net_3617 net_3618 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3619 VSS nch_25od w=10u l=0.5u
M_101 net_3620 net_3617 net_3621 VSS nch_25od w=10u l=0.5u
M_102 net_3619 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3619 net_3614 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3619 net_3614 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3621 VSS nch w=10u l=0.09u
M_106 net_3616 net_3615 VSS VSS nch w=10u l=0.09u
M_107 net_3620 I net_3619 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3614 net_3615 net_3618 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3622 net_3623 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3624 net_3617 net_3625 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3626 VSS nch_25od w=10u l=0.5u
M_112 net_3627 net_3617 net_3628 VSS nch_25od w=10u l=0.5u
M_113 net_3626 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3626 net_3622 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3626 net_3622 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3628 VSS nch w=10u l=0.09u
M_117 net_3624 net_3623 VSS VSS nch w=10u l=0.09u
M_118 net_3627 OEN net_3626 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3622 net_3623 net_3625 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3629 net_3630 VDDPST pch_25od w=40u l=0.415u
M_121 net_3630 net_3631 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3632 net_3629 net_3630 VSS nch_25od w=20u l=0.5u
M_123 net_3632 net_3631 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3633 net_3634 VSS nch w=3u l=0.1u
M_125 net_3633 net_3634 VDD VDD pch w=4u l=0.1u
M_126 net_3634 net_3633 net_3633 VDD pch w=4u l=0.1u
M_127 net_3604 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3606 net_3635 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3604 net_3634 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3604 net_3606 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3606 net_3604 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3617 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3617 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3610 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3636 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3637 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3590 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3634 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3638 net_3614 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3638 net_3614 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3631 net_3622 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3631 net_3622 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3612 net_3619 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3612 net_3619 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3629 net_3638 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3629 net_3638 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3613 net_3626 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3613 net_3626 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3615 I VSS VSS nch w=3u l=0.09u
M_152 net_3615 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3623 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3623 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3635 net_3634 VSS VSS nch w=3u l=0.09u
M_156 net_3635 net_3634 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3639 C VSS nch w=20u l=0.09u
M_158 VSS net_3640 net_3639 VSS nch w=10u l=0.09u
M_159 VDD net_3639 C VDD pch w=30u l=0.09u
M_160 VDD net_3640 net_3639 VDD pch w=10u l=0.09u
M_161 VSS net_3608 net_3641 VSS nch_25od w=0.6u l=0.5u
M_162 net_3640 net_3641 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3642 net_3631 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3643 net_3637 net_3642 VSS nch_25od w=10u l=0.5u
M_165 net_3589 net_3637 net_3630 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3608 net_3640 VSS nch_25od w=5u l=0.5u
M_167 net_3610 net_3637 net_3605 VSS nch_25od w=30u l=0.5u
M_168 net_3644 net_3637 net_3643 VSS nch_25od w=10u l=0.5u
M_169 net_3605 net_3613 net_3644 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3608 net_3641 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3643 net_3637 net_3610 net_3603 pch_25od w=26u l=0.415u
M_172 net_3589 net_3643 net_3630 net_3603 pch_25od w=26u l=0.415u
M_173 VDD net_3608 net_3640 VDD pch_25od w=5u l=0.415u
M_174 net_3603 net_3643 VDDPST net_3603 pch_25od w=24u l=0.415u
M_175 net_3603 net_3637 net_3610 net_3603 pch_25od w=24u l=0.415u
M_176 net_3589 net_3637 net_3610 net_3603 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDU24SDGZ
.SUBCKT PDUDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3645 net_3645 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_14 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_15 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_16 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_17 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_18 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_19 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_20 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_21 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_22 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_23 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_24 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_25 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_26 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_27 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
X_28 net_3646 net_3646 rppolywo w=0.4u l=1.3u m=1
M_29 net_3647 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3648 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3649 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3650 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3651 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3652 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3653 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3654 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3655 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3656 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_39 net_3657 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_40 net_3658 net_3645 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_3659 net_3647 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3659 net_3648 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3659 net_3649 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3659 net_3650 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3659 net_3651 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3659 net_3652 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3659 net_3653 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3659 net_3654 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3659 net_3655 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3659 net_3656 VSS nch_25od w=33u l=0.5u
M_51 PAD net_3659 net_3657 VSS nch_25od w=33u l=0.5u
M_52 PAD net_3659 net_3658 VSS nch_25od w=33u l=0.5u
M_53 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_54 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_55 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_56 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_57 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_58 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_59 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_60 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_61 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_62 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_63 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_64 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_65 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_66 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_67 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_68 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_69 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_70 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_71 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_72 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_73 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_74 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_75 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_76 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_77 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_78 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_79 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_80 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_81 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_82 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_83 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_84 PAD net_3646 VDDPST net_3646 pch_25od w=16.5u l=0.415u
M_85 VSS net_3660 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3646 net_3646 net_3646 net_3646 pch_25od w=0.5u l=0.9u
M_87 net_3661 net_3662 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3663 net_3661 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3664 net_3661 net_3663 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3664 net_3661 net_3665 VDDPST pch_25od w=5u l=0.415u
M_93 net_3665 net_3666 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3667 net_3668 net_3669 VDDPST pch_25od w=20u l=0.415u
M_95 net_3667 net_3670 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3669 net_3670 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3668 net_3669 VSS nch_25od w=15u l=0.5u
M_98 net_3671 net_3672 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3673 net_3674 net_3675 VSS nch_25od w=10u l=0.5u
M_100 VSS net_3676 net_3677 VSS nch_25od w=10u l=0.5u
M_101 net_3678 net_3674 net_3679 VSS nch_25od w=10u l=0.5u
M_102 net_3677 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3677 net_3671 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3677 net_3671 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_3676 net_3679 VSS nch w=10u l=0.09u
M_106 net_3673 net_3672 VSS VSS nch w=10u l=0.09u
M_107 net_3678 net_3676 net_3677 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3671 net_3672 net_3675 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3680 net_3681 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3682 net_3674 net_3683 VSS nch_25od w=10u l=0.5u
M_111 VSS net_3684 net_3685 VSS nch_25od w=10u l=0.5u
M_112 net_3686 net_3674 net_3687 VSS nch_25od w=10u l=0.5u
M_113 net_3685 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3685 net_3680 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3685 net_3680 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_3684 net_3687 VSS nch w=10u l=0.09u
M_117 net_3682 net_3681 VSS VSS nch w=10u l=0.09u
M_118 net_3686 net_3684 net_3685 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3680 net_3681 net_3683 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3688 net_3689 VDDPST pch_25od w=40u l=0.415u
M_121 net_3689 net_3690 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3691 net_3688 net_3689 VSS nch_25od w=20u l=0.5u
M_123 net_3691 net_3690 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3684 net_3676 VSS nch w=3u l=0.1u
M_125 net_3684 net_3676 VDD VDD pch w=4u l=0.1u
M_126 net_3676 net_3684 net_3684 VDD pch w=4u l=0.1u
M_127 net_3660 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3662 net_3692 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3660 net_3676 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3660 net_3662 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3662 net_3660 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3674 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3674 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3666 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3645 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3693 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3659 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3676 ndio area=4p
D_139 VSS net_3684 ndio area=4p
D_140 VSS net_3676 ndio area=4p
M_141 net_3694 net_3671 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3694 net_3671 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3690 net_3680 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3690 net_3680 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3668 net_3677 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3668 net_3677 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3688 net_3694 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3688 net_3694 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3670 net_3685 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3670 net_3685 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3672 net_3676 VSS VSS nch w=3u l=0.09u
M_152 net_3672 net_3676 VDD VDD pch w=7.5u l=0.09u
M_153 net_3681 net_3684 VSS VSS nch w=3u l=0.09u
M_154 net_3681 net_3684 VDD VDD pch w=7.5u l=0.09u
M_155 net_3692 net_3676 VSS VSS nch w=3u l=0.09u
M_156 net_3692 net_3676 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3695 C VSS nch w=20u l=0.09u
M_158 VSS net_3696 net_3695 VSS nch w=10u l=0.09u
M_159 VDD net_3695 C VDD pch w=30u l=0.09u
M_160 VDD net_3696 net_3695 VDD pch w=10u l=0.09u
M_161 VSS net_3664 net_3697 VSS nch_25od w=0.6u l=0.5u
M_162 net_3696 net_3697 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3698 net_3690 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3699 net_3693 net_3698 VSS nch_25od w=10u l=0.5u
M_165 net_3700 net_3693 net_3689 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3664 net_3696 VSS nch_25od w=5u l=0.5u
M_167 net_3666 net_3693 net_3661 VSS nch_25od w=30u l=0.5u
M_168 net_3701 net_3693 net_3699 VSS nch_25od w=10u l=0.5u
M_169 net_3661 net_3670 net_3701 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3664 net_3697 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3699 net_3693 net_3666 net_3646 pch_25od w=26u l=0.415u
M_172 net_3700 net_3699 net_3689 net_3646 pch_25od w=26u l=0.415u
M_173 VDD net_3664 net_3696 VDD pch_25od w=5u l=0.415u
M_174 net_3646 net_3699 VDDPST net_3646 pch_25od w=24u l=0.415u
M_175 net_3646 net_3693 net_3666 net_3646 pch_25od w=24u l=0.415u
M_176 net_3700 net_3693 net_3666 net_3646 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUDGZ
.SUBCKT PDUSDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3702 net_3702 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_14 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_15 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_16 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_17 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_18 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_19 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_20 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_21 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_22 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_23 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_24 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_25 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_26 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_27 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
X_28 net_3703 net_3703 rppolywo w=0.4u l=1.3u m=1
M_29 net_3704 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3705 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3706 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3707 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3708 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3709 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3710 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3711 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3712 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3713 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_39 net_3714 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_40 net_3715 net_3702 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_3716 net_3704 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3716 net_3705 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3716 net_3706 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3716 net_3707 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3716 net_3708 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3716 net_3709 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3716 net_3710 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3716 net_3711 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3716 net_3712 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3716 net_3713 VSS nch_25od w=33u l=0.5u
M_51 PAD net_3716 net_3714 VSS nch_25od w=33u l=0.5u
M_52 PAD net_3716 net_3715 VSS nch_25od w=33u l=0.5u
M_53 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_54 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_55 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_56 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_57 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_58 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_59 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_60 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_61 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_62 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_63 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_64 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_65 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_66 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_67 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_68 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_69 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_70 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_71 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_72 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_73 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_74 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_75 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_76 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_77 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_78 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_79 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_80 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_81 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_82 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_83 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_84 PAD net_3703 VDDPST net_3703 pch_25od w=16.5u l=0.415u
M_85 VSS net_3717 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3703 net_3703 net_3703 net_3703 pch_25od w=0.5u l=0.9u
M_87 net_3718 net_3719 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_3720 net_3721 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_3720 net_3718 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3721 net_3718 net_3720 VSS nch_25od w=5u l=0.5u
M_91 net_3722 net_3721 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3721 net_3718 net_3722 VDDPST pch_25od w=5u l=0.415u
M_93 net_3722 net_3723 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3724 net_3725 net_3726 VDDPST pch_25od w=20u l=0.415u
M_95 net_3724 net_3727 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3726 net_3727 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3725 net_3726 VSS nch_25od w=15u l=0.5u
M_98 net_3728 net_3729 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3730 net_3731 net_3732 VSS nch_25od w=10u l=0.5u
M_100 VSS net_3733 net_3734 VSS nch_25od w=10u l=0.5u
M_101 net_3735 net_3731 net_3736 VSS nch_25od w=10u l=0.5u
M_102 net_3734 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3734 net_3728 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3734 net_3728 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_3733 net_3736 VSS nch w=10u l=0.09u
M_106 net_3730 net_3729 VSS VSS nch w=10u l=0.09u
M_107 net_3735 net_3733 net_3734 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3728 net_3729 net_3732 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3737 net_3738 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3739 net_3731 net_3740 VSS nch_25od w=10u l=0.5u
M_111 VSS net_3741 net_3742 VSS nch_25od w=10u l=0.5u
M_112 net_3743 net_3731 net_3744 VSS nch_25od w=10u l=0.5u
M_113 net_3742 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3742 net_3737 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3742 net_3737 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_3741 net_3744 VSS nch w=10u l=0.09u
M_117 net_3739 net_3738 VSS VSS nch w=10u l=0.09u
M_118 net_3743 net_3741 net_3742 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3737 net_3738 net_3740 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3745 net_3746 VDDPST pch_25od w=40u l=0.415u
M_121 net_3746 net_3747 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3748 net_3745 net_3746 VSS nch_25od w=20u l=0.5u
M_123 net_3748 net_3747 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3741 net_3733 VSS nch w=3u l=0.1u
M_125 net_3741 net_3733 VDD VDD pch w=4u l=0.1u
M_126 net_3733 net_3741 net_3741 VDD pch w=4u l=0.1u
M_127 net_3717 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3719 net_3749 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3717 net_3733 VSS VSS nch_25od w=20u l=0.5u
M_130 net_3717 net_3719 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3719 net_3717 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3731 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3731 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3723 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3702 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3750 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3716 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_3733 ndio area=4p
D_139 VSS net_3741 ndio area=4p
D_140 VSS net_3733 ndio area=4p
M_141 net_3751 net_3728 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3751 net_3728 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3747 net_3737 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3747 net_3737 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3725 net_3734 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3725 net_3734 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3745 net_3751 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3745 net_3751 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3727 net_3742 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3727 net_3742 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3729 net_3733 VSS VSS nch w=3u l=0.09u
M_152 net_3729 net_3733 VDD VDD pch w=7.5u l=0.09u
M_153 net_3738 net_3741 VSS VSS nch w=3u l=0.09u
M_154 net_3738 net_3741 VDD VDD pch w=7.5u l=0.09u
M_155 net_3749 net_3733 VSS VSS nch w=3u l=0.09u
M_156 net_3749 net_3733 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3752 C VSS nch w=20u l=0.09u
M_158 VSS net_3753 net_3752 VSS nch w=10u l=0.09u
M_159 VDD net_3752 C VDD pch w=30u l=0.09u
M_160 VDD net_3753 net_3752 VDD pch w=10u l=0.09u
M_161 VSS net_3721 net_3754 VSS nch_25od w=0.6u l=0.5u
M_162 net_3753 net_3754 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3755 net_3747 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3756 net_3750 net_3755 VSS nch_25od w=10u l=0.5u
M_165 net_3757 net_3750 net_3746 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3721 net_3753 VSS nch_25od w=5u l=0.5u
M_167 net_3723 net_3750 net_3718 VSS nch_25od w=30u l=0.5u
M_168 net_3758 net_3750 net_3756 VSS nch_25od w=10u l=0.5u
M_169 net_3718 net_3727 net_3758 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3721 net_3754 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3756 net_3750 net_3723 net_3703 pch_25od w=26u l=0.415u
M_172 net_3757 net_3756 net_3746 net_3703 pch_25od w=26u l=0.415u
M_173 VDD net_3721 net_3753 VDD pch_25od w=5u l=0.415u
M_174 net_3703 net_3756 VDDPST net_3703 pch_25od w=24u l=0.415u
M_175 net_3703 net_3750 net_3723 net_3703 pch_25od w=24u l=0.415u
M_176 net_3757 net_3750 net_3723 net_3703 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUSDGZ
.SUBCKT PDUW02DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3760 net_3760 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3760 net_3760 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3759 net_3759 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_14 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_15 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_16 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_17 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_18 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_19 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_20 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_21 net_3762 net_3762 rppolywo w=0.4u l=1.3u m=1
X_22 net_3762 net_3762 rppolywo w=0.4u l=1.3u m=1
X_23 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_24 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_25 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_26 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_27 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
X_28 net_3761 net_3761 rppolywo w=0.4u l=1.3u m=1
M_29 net_3763 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3764 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3765 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3766 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3767 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3768 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3769 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3770 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3771 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3772 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_39 net_3773 net_3759 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_3774 net_3763 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3774 net_3764 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3774 net_3765 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3774 net_3766 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3774 net_3767 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3774 net_3768 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3774 net_3769 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3774 net_3770 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3774 net_3771 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3774 net_3772 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3774 net_3773 VSS nch_25od w=33u l=0.5u
M_51 PAD net_3774 net_3775 VSS nch_25od w=33u l=0.5u
M_52 net_3775 net_3760 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_54 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_55 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_56 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_57 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_58 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_59 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_60 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_61 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_62 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_63 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_64 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_65 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_66 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_67 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_68 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_69 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_70 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_71 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_72 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_73 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_74 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_75 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_76 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_77 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_78 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_79 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_80 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_81 PAD net_3761 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_82 PAD net_3762 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_83 PAD net_3762 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_84 PAD net_3762 VDDPST net_3761 pch_25od w=16.5u l=0.415u
M_85 VSS net_3776 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3761 net_3761 net_3761 net_3761 pch_25od w=0.5u l=0.9u
M_87 net_3777 net_3778 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3779 net_3777 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3780 net_3777 net_3779 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3780 net_3777 net_3781 VDDPST pch_25od w=5u l=0.415u
M_93 net_3781 net_3782 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3783 net_3784 net_3760 VDDPST pch_25od w=20u l=0.415u
M_95 net_3783 net_3785 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3760 net_3785 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3784 net_3760 VSS nch_25od w=15u l=0.5u
M_98 net_3786 net_3787 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3788 net_3789 net_3790 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3791 VSS nch_25od w=10u l=0.5u
M_101 net_3792 net_3789 net_3793 VSS nch_25od w=10u l=0.5u
M_102 net_3791 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3791 net_3786 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3791 net_3786 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3793 VSS nch w=10u l=0.09u
M_106 net_3788 net_3787 VSS VSS nch w=10u l=0.09u
M_107 net_3792 I net_3791 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3786 net_3787 net_3790 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3794 net_3795 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3796 net_3789 net_3797 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3798 VSS nch_25od w=10u l=0.5u
M_112 net_3799 net_3789 net_3800 VSS nch_25od w=10u l=0.5u
M_113 net_3798 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3798 net_3794 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3798 net_3794 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3800 VSS nch w=10u l=0.09u
M_117 net_3796 net_3795 VSS VSS nch w=10u l=0.09u
M_118 net_3799 OEN net_3798 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3794 net_3795 net_3797 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3801 net_3802 VDDPST pch_25od w=40u l=0.415u
M_121 net_3802 net_3803 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3804 net_3801 net_3802 VSS nch_25od w=20u l=0.5u
M_123 net_3804 net_3803 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3805 net_3806 VSS nch w=3u l=0.1u
M_125 net_3805 net_3806 VDD VDD pch w=4u l=0.1u
M_126 net_3806 net_3805 net_3805 VDD pch w=4u l=0.1u
M_127 net_3776 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3778 net_3807 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3776 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_3776 net_3778 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3778 net_3776 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3789 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3789 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3782 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3759 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3808 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3774 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3809 net_3786 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3809 net_3786 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3803 net_3794 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3803 net_3794 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3784 net_3791 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3784 net_3791 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3801 net_3809 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3801 net_3809 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3785 net_3798 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3785 net_3798 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3787 I VSS VSS nch w=3u l=0.09u
M_152 net_3787 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3795 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3795 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3807 REN VSS VSS nch w=3u l=0.09u
M_156 net_3807 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3810 C VSS nch w=20u l=0.09u
M_158 VSS net_3811 net_3810 VSS nch w=10u l=0.09u
M_159 VDD net_3810 C VDD pch w=30u l=0.09u
M_160 VDD net_3811 net_3810 VDD pch w=10u l=0.09u
M_161 VSS net_3780 net_3812 VSS nch_25od w=0.6u l=0.5u
M_162 net_3811 net_3812 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3813 net_3803 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3814 net_3808 net_3813 VSS nch_25od w=10u l=0.5u
M_165 net_3762 net_3808 net_3802 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3780 net_3811 VSS nch_25od w=5u l=0.5u
M_167 net_3782 net_3808 net_3777 VSS nch_25od w=30u l=0.5u
M_168 net_3815 net_3808 net_3814 VSS nch_25od w=10u l=0.5u
M_169 net_3777 net_3785 net_3815 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3780 net_3812 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3814 net_3808 net_3782 net_3761 pch_25od w=26u l=0.415u
M_172 net_3762 net_3814 net_3802 net_3761 pch_25od w=26u l=0.415u
M_173 VDD net_3780 net_3811 VDD pch_25od w=5u l=0.415u
M_174 net_3761 net_3814 VDDPST net_3761 pch_25od w=24u l=0.415u
M_175 net_3761 net_3808 net_3782 net_3761 pch_25od w=24u l=0.415u
M_176 net_3762 net_3808 net_3782 net_3761 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW02DGZ
.SUBCKT PDUW04DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3817 net_3817 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3817 net_3817 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3816 net_3816 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_14 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_15 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_16 net_3819 net_3819 rppolywo w=0.4u l=1.3u m=1
X_17 net_3819 net_3819 rppolywo w=0.4u l=1.3u m=1
X_18 net_3819 net_3819 rppolywo w=0.4u l=1.3u m=1
X_19 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_20 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_21 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_22 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_23 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_24 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_25 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_26 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_27 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
X_28 net_3818 net_3818 rppolywo w=0.4u l=1.3u m=1
M_29 net_3820 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3821 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3822 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3823 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3824 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3825 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3826 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3827 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_37 net_3828 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_38 net_3829 net_3816 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_3830 net_3820 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3830 net_3821 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3830 net_3822 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3830 net_3823 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3830 net_3824 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3830 net_3825 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3830 net_3826 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3830 net_3827 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3830 net_3828 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3830 net_3829 VSS nch_25od w=33u l=0.5u
M_49 PAD net_3830 net_3831 VSS nch_25od w=33u l=0.5u
M_50 PAD net_3830 net_3832 VSS nch_25od w=33u l=0.5u
M_51 net_3831 net_3817 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3832 net_3817 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_54 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_55 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_56 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_57 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_58 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_59 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_60 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_61 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_62 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_63 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_64 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_65 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_66 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_67 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_68 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_69 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_70 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_71 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_72 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_73 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_74 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_75 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_76 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_77 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_78 PAD net_3818 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_79 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_80 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_81 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_82 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_83 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_84 PAD net_3819 VDDPST net_3818 pch_25od w=16.5u l=0.415u
M_85 VSS net_3833 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3818 net_3818 net_3818 net_3818 pch_25od w=0.5u l=0.9u
M_87 net_3834 net_3835 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3836 net_3834 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3837 net_3834 net_3836 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3837 net_3834 net_3838 VDDPST pch_25od w=5u l=0.415u
M_93 net_3838 net_3839 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3840 net_3841 net_3817 VDDPST pch_25od w=20u l=0.415u
M_95 net_3840 net_3842 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3817 net_3842 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3841 net_3817 VSS nch_25od w=15u l=0.5u
M_98 net_3843 net_3844 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3845 net_3846 net_3847 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3848 VSS nch_25od w=10u l=0.5u
M_101 net_3849 net_3846 net_3850 VSS nch_25od w=10u l=0.5u
M_102 net_3848 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3848 net_3843 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3848 net_3843 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3850 VSS nch w=10u l=0.09u
M_106 net_3845 net_3844 VSS VSS nch w=10u l=0.09u
M_107 net_3849 I net_3848 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3843 net_3844 net_3847 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3851 net_3852 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3853 net_3846 net_3854 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3855 VSS nch_25od w=10u l=0.5u
M_112 net_3856 net_3846 net_3857 VSS nch_25od w=10u l=0.5u
M_113 net_3855 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3855 net_3851 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3855 net_3851 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3857 VSS nch w=10u l=0.09u
M_117 net_3853 net_3852 VSS VSS nch w=10u l=0.09u
M_118 net_3856 OEN net_3855 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3851 net_3852 net_3854 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3858 net_3859 VDDPST pch_25od w=40u l=0.415u
M_121 net_3859 net_3860 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3861 net_3858 net_3859 VSS nch_25od w=20u l=0.5u
M_123 net_3861 net_3860 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3862 net_3863 VSS nch w=3u l=0.1u
M_125 net_3862 net_3863 VDD VDD pch w=4u l=0.1u
M_126 net_3863 net_3862 net_3862 VDD pch w=4u l=0.1u
M_127 net_3833 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3835 net_3864 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3833 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_3833 net_3835 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3835 net_3833 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3846 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3846 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3839 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3816 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3865 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3830 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3866 net_3843 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3866 net_3843 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3860 net_3851 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3860 net_3851 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3841 net_3848 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3841 net_3848 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3858 net_3866 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3858 net_3866 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3842 net_3855 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3842 net_3855 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3844 I VSS VSS nch w=3u l=0.09u
M_152 net_3844 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3852 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3852 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3864 REN VSS VSS nch w=3u l=0.09u
M_156 net_3864 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3867 C VSS nch w=20u l=0.09u
M_158 VSS net_3868 net_3867 VSS nch w=10u l=0.09u
M_159 VDD net_3867 C VDD pch w=30u l=0.09u
M_160 VDD net_3868 net_3867 VDD pch w=10u l=0.09u
M_161 VSS net_3837 net_3869 VSS nch_25od w=0.6u l=0.5u
M_162 net_3868 net_3869 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3870 net_3860 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3871 net_3865 net_3870 VSS nch_25od w=10u l=0.5u
M_165 net_3819 net_3865 net_3859 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3837 net_3868 VSS nch_25od w=5u l=0.5u
M_167 net_3839 net_3865 net_3834 VSS nch_25od w=30u l=0.5u
M_168 net_3872 net_3865 net_3871 VSS nch_25od w=10u l=0.5u
M_169 net_3834 net_3842 net_3872 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3837 net_3869 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3871 net_3865 net_3839 net_3818 pch_25od w=26u l=0.415u
M_172 net_3819 net_3871 net_3859 net_3818 pch_25od w=26u l=0.415u
M_173 VDD net_3837 net_3868 VDD pch_25od w=5u l=0.415u
M_174 net_3818 net_3871 VDDPST net_3818 pch_25od w=24u l=0.415u
M_175 net_3818 net_3865 net_3839 net_3818 pch_25od w=24u l=0.415u
M_176 net_3819 net_3865 net_3839 net_3818 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW04DGZ
.SUBCKT PDUW08DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3874 net_3874 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3874 net_3874 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3874 net_3874 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3874 net_3874 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3873 net_3873 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_14 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_15 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_16 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_17 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_18 net_3875 net_3875 rppolywo w=0.4u l=1.3u m=1
X_19 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_20 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_21 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_22 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_23 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_24 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_25 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_26 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_27 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
X_28 net_3876 net_3876 rppolywo w=0.4u l=1.3u m=1
M_29 net_3877 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3878 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3879 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3880 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3881 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3882 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_35 net_3883 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_36 net_3884 net_3873 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_3885 net_3877 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3885 net_3878 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3885 net_3879 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3885 net_3880 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3885 net_3881 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3885 net_3882 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3885 net_3883 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3885 net_3884 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3885 net_3886 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3885 net_3887 VSS nch_25od w=33u l=0.5u
M_47 PAD net_3885 net_3888 VSS nch_25od w=33u l=0.5u
M_48 PAD net_3885 net_3889 VSS nch_25od w=33u l=0.5u
M_49 net_3886 net_3874 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3887 net_3874 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3888 net_3874 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3889 net_3874 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_54 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_55 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_56 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_57 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_58 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_59 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_60 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_61 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_62 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_63 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_64 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_65 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_66 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_67 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_68 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_69 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_70 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_71 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_72 PAD net_3876 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_73 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_74 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_75 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_76 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_77 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_78 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_79 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_80 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_81 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_82 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_83 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_84 PAD net_3875 VDDPST net_3876 pch_25od w=16.5u l=0.415u
M_85 VSS net_3890 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3876 net_3876 net_3876 net_3876 pch_25od w=0.5u l=0.9u
M_87 net_3891 net_3892 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3893 net_3891 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3894 net_3891 net_3893 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3894 net_3891 net_3895 VDDPST pch_25od w=5u l=0.415u
M_93 net_3895 net_3896 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3897 net_3898 net_3874 VDDPST pch_25od w=20u l=0.415u
M_95 net_3897 net_3899 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3874 net_3899 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3898 net_3874 VSS nch_25od w=15u l=0.5u
M_98 net_3900 net_3901 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3902 net_3903 net_3904 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3905 VSS nch_25od w=10u l=0.5u
M_101 net_3906 net_3903 net_3907 VSS nch_25od w=10u l=0.5u
M_102 net_3905 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3905 net_3900 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3905 net_3900 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3907 VSS nch w=10u l=0.09u
M_106 net_3902 net_3901 VSS VSS nch w=10u l=0.09u
M_107 net_3906 I net_3905 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3900 net_3901 net_3904 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3908 net_3909 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3910 net_3903 net_3911 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3912 VSS nch_25od w=10u l=0.5u
M_112 net_3913 net_3903 net_3914 VSS nch_25od w=10u l=0.5u
M_113 net_3912 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3912 net_3908 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3912 net_3908 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3914 VSS nch w=10u l=0.09u
M_117 net_3910 net_3909 VSS VSS nch w=10u l=0.09u
M_118 net_3913 OEN net_3912 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3908 net_3909 net_3911 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3915 net_3916 VDDPST pch_25od w=40u l=0.415u
M_121 net_3916 net_3917 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3918 net_3915 net_3916 VSS nch_25od w=20u l=0.5u
M_123 net_3918 net_3917 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3919 net_3920 VSS nch w=3u l=0.1u
M_125 net_3919 net_3920 VDD VDD pch w=4u l=0.1u
M_126 net_3920 net_3919 net_3919 VDD pch w=4u l=0.1u
M_127 net_3890 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3892 net_3921 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3890 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_3890 net_3892 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3892 net_3890 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3903 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3903 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3896 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3873 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3922 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3885 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3923 net_3900 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3923 net_3900 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3917 net_3908 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3917 net_3908 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3898 net_3905 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3898 net_3905 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3915 net_3923 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3915 net_3923 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3899 net_3912 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3899 net_3912 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3901 I VSS VSS nch w=3u l=0.09u
M_152 net_3901 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3909 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3909 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3921 REN VSS VSS nch w=3u l=0.09u
M_156 net_3921 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3924 C VSS nch w=20u l=0.09u
M_158 VSS net_3925 net_3924 VSS nch w=10u l=0.09u
M_159 VDD net_3924 C VDD pch w=30u l=0.09u
M_160 VDD net_3925 net_3924 VDD pch w=10u l=0.09u
M_161 VSS net_3894 net_3926 VSS nch_25od w=0.6u l=0.5u
M_162 net_3925 net_3926 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3927 net_3917 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3928 net_3922 net_3927 VSS nch_25od w=10u l=0.5u
M_165 net_3875 net_3922 net_3916 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3894 net_3925 VSS nch_25od w=5u l=0.5u
M_167 net_3896 net_3922 net_3891 VSS nch_25od w=30u l=0.5u
M_168 net_3929 net_3922 net_3928 VSS nch_25od w=10u l=0.5u
M_169 net_3891 net_3899 net_3929 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3894 net_3926 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3928 net_3922 net_3896 net_3876 pch_25od w=26u l=0.415u
M_172 net_3875 net_3928 net_3916 net_3876 pch_25od w=26u l=0.415u
M_173 VDD net_3894 net_3925 VDD pch_25od w=5u l=0.415u
M_174 net_3876 net_3928 VDDPST net_3876 pch_25od w=24u l=0.415u
M_175 net_3876 net_3922 net_3896 net_3876 pch_25od w=24u l=0.415u
M_176 net_3875 net_3922 net_3896 net_3876 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW08DGZ
.SUBCKT PDUW12DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3930 net_3930 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3931 net_3931 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_14 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_15 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_16 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_17 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_18 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_19 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_20 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_21 net_3932 net_3932 rppolywo w=0.4u l=1.3u m=1
X_22 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_23 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_24 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_25 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_26 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_27 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
X_28 net_3933 net_3933 rppolywo w=0.4u l=1.3u m=1
M_29 net_3934 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3935 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3936 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3937 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_33 net_3938 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_34 net_3939 net_3931 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_3940 net_3934 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3940 net_3935 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3940 net_3936 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3940 net_3937 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3940 net_3938 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3940 net_3939 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3940 net_3941 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3940 net_3942 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3940 net_3943 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3940 net_3944 VSS nch_25od w=33u l=0.5u
M_45 PAD net_3940 net_3945 VSS nch_25od w=33u l=0.5u
M_46 PAD net_3940 net_3946 VSS nch_25od w=33u l=0.5u
M_47 net_3941 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3942 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_49 net_3943 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_50 net_3944 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_51 net_3945 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_52 net_3946 net_3930 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_54 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_55 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_56 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_57 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_58 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_59 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_60 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_61 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_62 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_63 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_64 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_65 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_66 PAD net_3933 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_67 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_68 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_69 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_70 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_71 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_72 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_73 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_74 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_75 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_76 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_77 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_78 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_79 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_80 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_81 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_82 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_83 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_84 PAD net_3932 VDDPST net_3933 pch_25od w=16.5u l=0.415u
M_85 VSS net_3947 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3933 net_3933 net_3933 net_3933 pch_25od w=0.5u l=0.9u
M_87 net_3948 net_3949 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_3950 net_3948 VSS VSS nch_25od w=5u l=0.5u
M_90 net_3951 net_3948 net_3950 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_3951 net_3948 net_3952 VDDPST pch_25od w=5u l=0.415u
M_93 net_3952 net_3953 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_3954 net_3955 net_3930 VDDPST pch_25od w=20u l=0.415u
M_95 net_3954 net_3956 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3930 net_3956 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_3955 net_3930 VSS nch_25od w=15u l=0.5u
M_98 net_3957 net_3958 VSS VSS nch_25od w=10u l=0.5u
M_99 net_3959 net_3960 net_3961 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_3962 VSS nch_25od w=10u l=0.5u
M_101 net_3963 net_3960 net_3964 VSS nch_25od w=10u l=0.5u
M_102 net_3962 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_3962 net_3957 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_3962 net_3957 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_3964 VSS nch w=10u l=0.09u
M_106 net_3959 net_3958 VSS VSS nch w=10u l=0.09u
M_107 net_3963 I net_3962 VSS nch_na25 w=5.5u l=1.32u
M_108 net_3957 net_3958 net_3961 VSS nch_na25 w=5.5u l=1.32u
M_109 net_3965 net_3966 VSS VSS nch_25od w=10u l=0.5u
M_110 net_3967 net_3960 net_3968 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_3969 VSS nch_25od w=10u l=0.5u
M_112 net_3970 net_3960 net_3971 VSS nch_25od w=10u l=0.5u
M_113 net_3969 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_3969 net_3965 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_3969 net_3965 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_3971 VSS nch w=10u l=0.09u
M_117 net_3967 net_3966 VSS VSS nch w=10u l=0.09u
M_118 net_3970 OEN net_3969 VSS nch_na25 w=5.5u l=1.32u
M_119 net_3965 net_3966 net_3968 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_3972 net_3973 VDDPST pch_25od w=40u l=0.415u
M_121 net_3973 net_3974 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_3975 net_3972 net_3973 VSS nch_25od w=20u l=0.5u
M_123 net_3975 net_3974 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_3976 net_3977 VSS nch w=3u l=0.1u
M_125 net_3976 net_3977 VDD VDD pch w=4u l=0.1u
M_126 net_3977 net_3976 net_3976 VDD pch w=4u l=0.1u
M_127 net_3947 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_3949 net_3978 VSS VSS nch_25od w=20u l=0.5u
M_129 net_3947 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_3947 net_3949 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_3949 net_3947 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_3960 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_3960 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_3953 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3931 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_3979 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3940 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_3980 net_3957 VSS VSS nch_25od w=2u l=0.5u
M_142 net_3980 net_3957 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_3974 net_3965 VSS VSS nch_25od w=3u l=0.5u
M_144 net_3974 net_3965 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_3955 net_3962 VSS VSS nch_25od w=7u l=0.5u
M_146 net_3955 net_3962 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_3972 net_3980 VSS VSS nch_25od w=10u l=0.5u
M_148 net_3972 net_3980 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_3956 net_3969 VSS VSS nch_25od w=3u l=0.5u
M_150 net_3956 net_3969 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_3958 I VSS VSS nch w=3u l=0.09u
M_152 net_3958 I VDD VDD pch w=7.5u l=0.09u
M_153 net_3966 OEN VSS VSS nch w=3u l=0.09u
M_154 net_3966 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_3978 REN VSS VSS nch w=3u l=0.09u
M_156 net_3978 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_3981 C VSS nch w=20u l=0.09u
M_158 VSS net_3982 net_3981 VSS nch w=10u l=0.09u
M_159 VDD net_3981 C VDD pch w=30u l=0.09u
M_160 VDD net_3982 net_3981 VDD pch w=10u l=0.09u
M_161 VSS net_3951 net_3983 VSS nch_25od w=0.6u l=0.5u
M_162 net_3982 net_3983 VDD VSS nch_25od w=5u l=0.5u
M_163 net_3984 net_3974 VSS VSS nch_25od w=10u l=0.5u
M_164 net_3985 net_3979 net_3984 VSS nch_25od w=10u l=0.5u
M_165 net_3932 net_3979 net_3973 VSS nch_25od w=30u l=0.5u
M_166 VSS net_3951 net_3982 VSS nch_25od w=5u l=0.5u
M_167 net_3953 net_3979 net_3948 VSS nch_25od w=30u l=0.5u
M_168 net_3986 net_3979 net_3985 VSS nch_25od w=10u l=0.5u
M_169 net_3948 net_3956 net_3986 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_3951 net_3983 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_3985 net_3979 net_3953 net_3933 pch_25od w=26u l=0.415u
M_172 net_3932 net_3985 net_3973 net_3933 pch_25od w=26u l=0.415u
M_173 VDD net_3951 net_3982 VDD pch_25od w=5u l=0.415u
M_174 net_3933 net_3985 VDDPST net_3933 pch_25od w=24u l=0.415u
M_175 net_3933 net_3979 net_3953 net_3933 pch_25od w=24u l=0.415u
M_176 net_3932 net_3979 net_3953 net_3933 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW12DGZ
.SUBCKT PDUW16DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_3987 net_3987 rnpolywo w=0.4u l=2.93u m=1
X_2 net_3987 net_3987 rnpolywo w=0.4u l=2.93u m=1
X_3 net_3987 net_3987 rnpolywo w=0.4u l=2.93u m=1
X_4 net_3987 net_3987 rnpolywo w=0.4u l=2.93u m=1
X_5 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_6 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_7 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_8 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_9 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_10 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_11 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_12 net_3988 net_3988 rnpolywo w=0.4u l=2.93u m=1
X_13 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_14 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_15 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_16 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_17 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_18 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_19 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_20 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_21 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_22 net_3990 net_3990 rppolywo w=0.4u l=1.3u m=1
X_23 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_24 net_3990 net_3990 rppolywo w=0.4u l=1.3u m=1
X_25 net_3990 net_3990 rppolywo w=0.4u l=1.3u m=1
X_26 net_3990 net_3990 rppolywo w=0.4u l=1.3u m=1
X_27 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
X_28 net_3989 net_3989 rppolywo w=0.4u l=1.3u m=1
M_29 net_3991 net_3987 VSS VSS nch_25od w=33u l=0.5u
M_30 net_3992 net_3987 VSS VSS nch_25od w=33u l=0.5u
M_31 net_3993 net_3987 VSS VSS nch_25od w=33u l=0.5u
M_32 net_3994 net_3987 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_3995 net_3991 VSS nch_25od w=33u l=0.5u
M_34 PAD net_3995 net_3992 VSS nch_25od w=33u l=0.5u
M_35 PAD net_3995 net_3993 VSS nch_25od w=33u l=0.5u
M_36 PAD net_3995 net_3994 VSS nch_25od w=33u l=0.5u
M_37 PAD net_3995 net_3996 VSS nch_25od w=33u l=0.5u
M_38 PAD net_3995 net_3997 VSS nch_25od w=33u l=0.5u
M_39 PAD net_3995 net_3998 VSS nch_25od w=33u l=0.5u
M_40 PAD net_3995 net_3999 VSS nch_25od w=33u l=0.5u
M_41 PAD net_3995 net_4000 VSS nch_25od w=33u l=0.5u
M_42 PAD net_3995 net_4001 VSS nch_25od w=33u l=0.5u
M_43 PAD net_3995 net_4002 VSS nch_25od w=33u l=0.5u
M_44 PAD net_3995 net_4003 VSS nch_25od w=33u l=0.5u
M_45 net_3996 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_46 net_3997 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_47 net_3998 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_48 net_3999 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_49 net_4000 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_50 net_4001 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_51 net_4002 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4003 net_3988 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_54 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_55 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_56 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_57 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_58 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_59 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_60 PAD net_3990 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_61 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_62 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_63 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_64 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_65 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_66 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_67 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_68 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_69 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_70 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_71 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_72 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_73 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_74 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_75 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_76 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_77 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_78 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_79 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_80 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_81 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_82 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_83 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_84 PAD net_3989 VDDPST net_3990 pch_25od w=16.5u l=0.415u
M_85 VSS net_4004 VSS VSS nch_25od w=0.5u l=3u
M_86 net_3990 net_3990 net_3990 net_3990 pch_25od w=0.5u l=0.9u
M_87 net_4005 net_4006 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4007 net_4005 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4008 net_4005 net_4007 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4008 net_4005 net_4009 VDDPST pch_25od w=5u l=0.415u
M_93 net_4009 net_4010 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4011 net_4012 net_3988 VDDPST pch_25od w=20u l=0.415u
M_95 net_4011 net_4013 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3988 net_4013 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4012 net_3988 VSS nch_25od w=15u l=0.5u
M_98 net_4014 net_4015 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4016 net_4017 net_4018 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4019 VSS nch_25od w=10u l=0.5u
M_101 net_4020 net_4017 net_4021 VSS nch_25od w=10u l=0.5u
M_102 net_4019 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4019 net_4014 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4019 net_4014 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4021 VSS nch w=10u l=0.09u
M_106 net_4016 net_4015 VSS VSS nch w=10u l=0.09u
M_107 net_4020 I net_4019 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4014 net_4015 net_4018 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4022 net_4023 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4024 net_4017 net_4025 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4026 VSS nch_25od w=10u l=0.5u
M_112 net_4027 net_4017 net_4028 VSS nch_25od w=10u l=0.5u
M_113 net_4026 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4026 net_4022 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4026 net_4022 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4028 VSS nch w=10u l=0.09u
M_117 net_4024 net_4023 VSS VSS nch w=10u l=0.09u
M_118 net_4027 OEN net_4026 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4022 net_4023 net_4025 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4029 net_4030 VDDPST pch_25od w=40u l=0.415u
M_121 net_4030 net_4031 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4032 net_4029 net_4030 VSS nch_25od w=20u l=0.5u
M_123 net_4032 net_4031 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4033 net_4034 VSS nch w=3u l=0.1u
M_125 net_4033 net_4034 VDD VDD pch w=4u l=0.1u
M_126 net_4034 net_4033 net_4033 VDD pch w=4u l=0.1u
M_127 net_4004 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4006 net_4035 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4004 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_4004 net_4006 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4006 net_4004 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4017 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4017 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4010 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_3987 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4036 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_3995 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4037 net_4014 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4037 net_4014 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4031 net_4022 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4031 net_4022 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4012 net_4019 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4012 net_4019 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4029 net_4037 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4029 net_4037 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4013 net_4026 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4013 net_4026 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4015 I VSS VSS nch w=3u l=0.09u
M_152 net_4015 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4023 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4023 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4035 REN VSS VSS nch w=3u l=0.09u
M_156 net_4035 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4038 C VSS nch w=20u l=0.09u
M_158 VSS net_4039 net_4038 VSS nch w=10u l=0.09u
M_159 VDD net_4038 C VDD pch w=30u l=0.09u
M_160 VDD net_4039 net_4038 VDD pch w=10u l=0.09u
M_161 VSS net_4008 net_4040 VSS nch_25od w=0.6u l=0.5u
M_162 net_4039 net_4040 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4041 net_4031 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4042 net_4036 net_4041 VSS nch_25od w=10u l=0.5u
M_165 net_3989 net_4036 net_4030 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4008 net_4039 VSS nch_25od w=5u l=0.5u
M_167 net_4010 net_4036 net_4005 VSS nch_25od w=30u l=0.5u
M_168 net_4043 net_4036 net_4042 VSS nch_25od w=10u l=0.5u
M_169 net_4005 net_4013 net_4043 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4008 net_4040 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4042 net_4036 net_4010 net_3990 pch_25od w=26u l=0.415u
M_172 net_3989 net_4042 net_4030 net_3990 pch_25od w=26u l=0.415u
M_173 VDD net_4008 net_4039 VDD pch_25od w=5u l=0.415u
M_174 net_3990 net_4042 VDDPST net_3990 pch_25od w=24u l=0.415u
M_175 net_3990 net_4036 net_4010 net_3990 pch_25od w=24u l=0.415u
M_176 net_3989 net_4036 net_4010 net_3990 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW16DGZ
.SUBCKT PDUW24DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4044 net_4044 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_14 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_15 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_16 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_17 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_18 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_19 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_20 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_21 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_22 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_23 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_24 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_25 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_26 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_27 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
X_28 net_4045 net_4045 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4046 net_4047 VSS nch_25od w=33u l=0.5u
M_30 PAD net_4046 net_4048 VSS nch_25od w=33u l=0.5u
M_31 PAD net_4046 net_4049 VSS nch_25od w=33u l=0.5u
M_32 PAD net_4046 net_4050 VSS nch_25od w=33u l=0.5u
M_33 PAD net_4046 net_4051 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4046 net_4052 VSS nch_25od w=33u l=0.5u
M_35 PAD net_4046 net_4053 VSS nch_25od w=33u l=0.5u
M_36 PAD net_4046 net_4054 VSS nch_25od w=33u l=0.5u
M_37 PAD net_4046 net_4055 VSS nch_25od w=33u l=0.5u
M_38 PAD net_4046 net_4056 VSS nch_25od w=33u l=0.5u
M_39 PAD net_4046 net_4057 VSS nch_25od w=33u l=0.5u
M_40 PAD net_4046 net_4058 VSS nch_25od w=33u l=0.5u
M_41 net_4047 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_42 net_4048 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_43 net_4049 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_44 net_4050 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_45 net_4051 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_46 net_4052 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_47 net_4053 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_48 net_4054 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_49 net_4055 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_50 net_4056 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_51 net_4057 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4058 net_4044 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_54 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_55 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_56 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_57 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_58 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_59 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_60 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_61 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_62 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_63 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_64 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_65 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_66 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_67 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_68 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_69 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_70 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_71 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_72 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_73 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_74 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_75 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_76 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_77 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_78 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_79 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_80 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_81 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_82 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_83 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_84 PAD net_4045 VDDPST net_4059 pch_25od w=16.5u l=0.415u
M_85 VSS net_4060 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4059 net_4059 net_4059 net_4059 pch_25od w=0.5u l=0.9u
M_87 net_4061 net_4062 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4063 net_4061 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4064 net_4061 net_4063 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4064 net_4061 net_4065 VDDPST pch_25od w=5u l=0.415u
M_93 net_4065 net_4066 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4067 net_4068 net_4044 VDDPST pch_25od w=20u l=0.415u
M_95 net_4067 net_4069 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4044 net_4069 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4068 net_4044 VSS nch_25od w=15u l=0.5u
M_98 net_4070 net_4071 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4072 net_4073 net_4074 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4075 VSS nch_25od w=10u l=0.5u
M_101 net_4076 net_4073 net_4077 VSS nch_25od w=10u l=0.5u
M_102 net_4075 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4075 net_4070 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4075 net_4070 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4077 VSS nch w=10u l=0.09u
M_106 net_4072 net_4071 VSS VSS nch w=10u l=0.09u
M_107 net_4076 I net_4075 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4070 net_4071 net_4074 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4078 net_4079 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4080 net_4073 net_4081 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4082 VSS nch_25od w=10u l=0.5u
M_112 net_4083 net_4073 net_4084 VSS nch_25od w=10u l=0.5u
M_113 net_4082 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4082 net_4078 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4082 net_4078 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4084 VSS nch w=10u l=0.09u
M_117 net_4080 net_4079 VSS VSS nch w=10u l=0.09u
M_118 net_4083 OEN net_4082 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4078 net_4079 net_4081 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4085 net_4086 VDDPST pch_25od w=40u l=0.415u
M_121 net_4086 net_4087 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4088 net_4085 net_4086 VSS nch_25od w=20u l=0.5u
M_123 net_4088 net_4087 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4089 net_4090 VSS nch w=3u l=0.1u
M_125 net_4089 net_4090 VDD VDD pch w=4u l=0.1u
M_126 net_4090 net_4089 net_4089 VDD pch w=4u l=0.1u
M_127 net_4060 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4062 net_4091 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4060 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_4060 net_4062 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4062 net_4060 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4073 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4073 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4066 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4092 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4093 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4046 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4094 net_4070 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4094 net_4070 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4087 net_4078 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4087 net_4078 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4068 net_4075 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4068 net_4075 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4085 net_4094 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4085 net_4094 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4069 net_4082 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4069 net_4082 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4071 I VSS VSS nch w=3u l=0.09u
M_152 net_4071 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4079 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4079 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4091 REN VSS VSS nch w=3u l=0.09u
M_156 net_4091 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4095 C VSS nch w=20u l=0.09u
M_158 VSS net_4096 net_4095 VSS nch w=10u l=0.09u
M_159 VDD net_4095 C VDD pch w=30u l=0.09u
M_160 VDD net_4096 net_4095 VDD pch w=10u l=0.09u
M_161 VSS net_4064 net_4097 VSS nch_25od w=0.6u l=0.5u
M_162 net_4096 net_4097 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4098 net_4087 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4099 net_4093 net_4098 VSS nch_25od w=10u l=0.5u
M_165 net_4045 net_4093 net_4086 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4064 net_4096 VSS nch_25od w=5u l=0.5u
M_167 net_4066 net_4093 net_4061 VSS nch_25od w=30u l=0.5u
M_168 net_4100 net_4093 net_4099 VSS nch_25od w=10u l=0.5u
M_169 net_4061 net_4069 net_4100 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4064 net_4097 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4099 net_4093 net_4066 net_4059 pch_25od w=26u l=0.415u
M_172 net_4045 net_4099 net_4086 net_4059 pch_25od w=26u l=0.415u
M_173 VDD net_4064 net_4096 VDD pch_25od w=5u l=0.415u
M_174 net_4059 net_4099 VDDPST net_4059 pch_25od w=24u l=0.415u
M_175 net_4059 net_4093 net_4066 net_4059 pch_25od w=24u l=0.415u
M_176 net_4045 net_4093 net_4066 net_4059 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUW24DGZ
.SUBCKT PDUWDGZ C PAD REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4101 net_4101 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_14 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_15 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_16 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_17 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_18 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_19 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_20 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_21 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_22 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_23 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_24 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_25 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_26 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_27 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
X_28 net_4102 net_4102 rppolywo w=0.4u l=1.3u m=1
M_29 net_4103 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_30 net_4104 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_31 net_4105 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4106 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4107 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4108 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4109 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4110 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4111 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4112 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4113 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4114 net_4101 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_4115 net_4103 VSS nch_25od w=33u l=0.5u
M_42 PAD net_4115 net_4104 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4115 net_4105 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4115 net_4106 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4115 net_4107 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4115 net_4108 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4115 net_4109 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4115 net_4110 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4115 net_4111 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4115 net_4112 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4115 net_4113 VSS nch_25od w=33u l=0.5u
M_52 PAD net_4115 net_4114 VSS nch_25od w=33u l=0.5u
M_53 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_54 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_55 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_56 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_57 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_58 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_59 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_60 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_61 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_62 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_63 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_64 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_65 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_66 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_67 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_68 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_69 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_70 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_71 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_72 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_73 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_74 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_75 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_76 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_77 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_78 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_79 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_80 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_81 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_82 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_83 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_84 PAD net_4102 VDDPST net_4102 pch_25od w=16.5u l=0.415u
M_85 VSS net_4116 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4102 net_4102 net_4102 net_4102 pch_25od w=0.5u l=0.9u
M_87 net_4117 net_4118 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4119 net_4117 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4120 net_4117 net_4119 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4120 net_4117 net_4121 VDDPST pch_25od w=5u l=0.415u
M_93 net_4121 net_4122 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4123 net_4124 net_4125 VDDPST pch_25od w=20u l=0.415u
M_95 net_4123 net_4126 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4125 net_4126 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4124 net_4125 VSS nch_25od w=15u l=0.5u
M_98 net_4127 net_4128 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4129 net_4130 net_4131 VSS nch_25od w=10u l=0.5u
M_100 VSS net_4132 net_4133 VSS nch_25od w=10u l=0.5u
M_101 net_4134 net_4130 net_4135 VSS nch_25od w=10u l=0.5u
M_102 net_4133 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4133 net_4127 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4133 net_4127 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_4132 net_4135 VSS nch w=10u l=0.09u
M_106 net_4129 net_4128 VSS VSS nch w=10u l=0.09u
M_107 net_4134 net_4132 net_4133 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4127 net_4128 net_4131 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4136 net_4137 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4138 net_4130 net_4139 VSS nch_25od w=10u l=0.5u
M_111 VSS net_4140 net_4141 VSS nch_25od w=10u l=0.5u
M_112 net_4142 net_4130 net_4143 VSS nch_25od w=10u l=0.5u
M_113 net_4141 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4141 net_4136 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4141 net_4136 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_4140 net_4143 VSS nch w=10u l=0.09u
M_117 net_4138 net_4137 VSS VSS nch w=10u l=0.09u
M_118 net_4142 net_4140 net_4141 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4136 net_4137 net_4139 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4144 net_4145 VDDPST pch_25od w=40u l=0.415u
M_121 net_4145 net_4146 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4147 net_4144 net_4145 VSS nch_25od w=20u l=0.5u
M_123 net_4147 net_4146 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4140 net_4132 VSS nch w=3u l=0.1u
M_125 net_4140 net_4132 VDD VDD pch w=4u l=0.1u
M_126 net_4132 net_4140 net_4140 VDD pch w=4u l=0.1u
M_127 net_4116 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4118 net_4148 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4116 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_4116 net_4118 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4118 net_4116 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4130 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4130 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4122 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4101 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4149 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4115 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS net_4140 ndio area=4p
D_140 VSS net_4132 ndio area=4p
M_141 net_4150 net_4127 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4150 net_4127 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4146 net_4136 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4146 net_4136 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4124 net_4133 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4124 net_4133 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4144 net_4150 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4144 net_4150 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4126 net_4141 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4126 net_4141 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4128 net_4132 VSS VSS nch w=3u l=0.09u
M_152 net_4128 net_4132 VDD VDD pch w=7.5u l=0.09u
M_153 net_4137 net_4140 VSS VSS nch w=3u l=0.09u
M_154 net_4137 net_4140 VDD VDD pch w=7.5u l=0.09u
M_155 net_4148 REN VSS VSS nch w=3u l=0.09u
M_156 net_4148 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4151 C VSS nch w=20u l=0.09u
M_158 VSS net_4152 net_4151 VSS nch w=10u l=0.09u
M_159 VDD net_4151 C VDD pch w=30u l=0.09u
M_160 VDD net_4152 net_4151 VDD pch w=10u l=0.09u
M_161 VSS net_4120 net_4153 VSS nch_25od w=0.6u l=0.5u
M_162 net_4152 net_4153 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4154 net_4146 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4155 net_4149 net_4154 VSS nch_25od w=10u l=0.5u
M_165 net_4156 net_4149 net_4145 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4120 net_4152 VSS nch_25od w=5u l=0.5u
M_167 net_4122 net_4149 net_4117 VSS nch_25od w=30u l=0.5u
M_168 net_4157 net_4149 net_4155 VSS nch_25od w=10u l=0.5u
M_169 net_4117 net_4126 net_4157 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4120 net_4153 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4155 net_4149 net_4122 net_4102 pch_25od w=26u l=0.415u
M_172 net_4156 net_4155 net_4145 net_4102 pch_25od w=26u l=0.415u
M_173 VDD net_4120 net_4152 VDD pch_25od w=5u l=0.415u
M_174 net_4102 net_4155 VDDPST net_4102 pch_25od w=24u l=0.415u
M_175 net_4102 net_4149 net_4122 net_4102 pch_25od w=24u l=0.415u
M_176 net_4156 net_4149 net_4122 net_4102 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDUWDGZ
.SUBCKT PDXO01DG XC XOUT XIN
M_0 VSS net_4158 net_4159 VSS nch w=3u l=0.1u
M_1 net_4158 net_4159 VDD VDD pch w=4u l=0.1u
M_2 net_4159 net_4158 net_4158 VDD pch w=4u l=0.1u
X_3 VDDPST net_4160 rppolywo w=1.84u l=2.76u m=1
X_4 net_4161 VSS rppolywo w=1.84u l=2.76u m=1
X_5 VDDPST net_4162 rppolywo w=1.84u l=2.76u m=1
X_6 net_4163 VSS rppolywo w=1.84u l=2.76u m=1
X_7 XIN net_4164 rnpolywo w=2u l=3.68u m=1
X_8 XOUT net_4165 rnpolywo w=2u l=3.68u m=1
D_9 VSS XOUT ndio_esd area=559.176p
D_10 VSS XIN ndio_esd area=643.656p
M_11 VDD net_4166 XC VDD pch w=24u l=0.09u
M_12 VSS net_4166 XC VSS nch w=9u l=0.09u
M_13 net_4167 net_4158 VSS VSS nch w=3u l=0.09u
M_14 net_4167 net_4158 VDD VDD pch w=7.5u l=0.09u
M_15 net_4168 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4169 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4170 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4171 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4172 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4173 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4174 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_22 net_4175 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_23 net_4176 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_24 net_4177 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_25 net_4178 net_4163 VSS VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4163 net_4169 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4163 net_4170 VSS nch_25od w=33u l=0.5u
M_28 XOUT net_4163 net_4171 VSS nch_25od w=33u l=0.5u
M_29 XOUT net_4163 net_4172 VSS nch_25od w=33u l=0.5u
M_30 XOUT net_4163 net_4173 VSS nch_25od w=33u l=0.5u
M_31 XOUT net_4163 net_4174 VSS nch_25od w=33u l=0.5u
M_32 XOUT net_4163 net_4175 VSS nch_25od w=33u l=0.5u
M_33 XOUT net_4163 net_4176 VSS nch_25od w=33u l=0.5u
M_34 XOUT net_4163 net_4177 VSS nch_25od w=33u l=0.5u
M_35 XOUT net_4163 net_4178 VSS nch_25od w=33u l=0.5u
M_36 net_4179 net_4180 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4181 net_4180 VSS VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4164 net_4179 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4164 net_4181 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4161 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4182 net_4165 net_4183 VSS nch_25od w=15u l=0.5u
M_53 net_4183 net_4165 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4182 net_4183 VSS nch_25od w=15u l=0.5u
M_55 net_4180 net_4168 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4166 net_4182 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4165 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4168 net_4158 VSS VSS nch_25od w=20u l=0.5u
M_59 net_4184 net_4167 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4162 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_106 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_107 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_108 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_112 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_113 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_114 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4160 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 net_4185 net_4165 VDDPST VDDPST pch_25od w=20u l=0.415u
M_118 net_4182 net_4165 net_4185 VDDPST pch_25od w=20u l=0.415u
M_119 VSS net_4182 net_4185 VDDPST pch_25od w=20u l=0.415u
M_120 XOUT net_4180 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4164 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4180 net_4168 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4166 net_4182 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4165 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4184 net_4168 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4168 net_4184 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXO01DG
.SUBCKT PDXO02DG XC XOUT XIN
M_0 VSS net_4186 net_4187 VSS nch w=3u l=0.1u
M_1 net_4186 net_4187 VDD VDD pch w=4u l=0.1u
M_2 net_4187 net_4186 net_4186 VDD pch w=4u l=0.1u
X_3 net_4188 VSS rppolywo w=1.84u l=2.76u m=1
X_4 net_4189 VSS rppolywo w=1.84u l=2.76u m=1
X_5 VDDPST net_4190 rppolywo w=1.84u l=2.76u m=1
X_6 VDDPST net_4191 rppolywo w=1.84u l=2.76u m=1
X_7 XIN net_4192 rnpolywo w=2u l=3.68u m=1
X_8 XOUT net_4193 rnpolywo w=2u l=3.68u m=1
D_9 VSS XIN ndio_esd area=643.656p
D_10 VSS XOUT ndio_esd area=559.176p
M_11 VDD net_4194 XC VDD pch w=24u l=0.09u
M_12 VSS net_4194 XC VSS nch w=9u l=0.09u
M_13 net_4195 net_4186 VSS VSS nch w=3u l=0.09u
M_14 net_4195 net_4186 VDD VDD pch w=7.5u l=0.09u
M_15 net_4196 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4197 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4198 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4199 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4200 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4201 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4202 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_22 net_4203 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_23 net_4204 net_4189 VSS VSS nch_25od w=33u l=0.5u
M_24 XOUT net_4189 net_4197 VSS nch_25od w=33u l=0.5u
M_25 XOUT net_4189 net_4198 VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4189 net_4199 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4189 net_4200 VSS nch_25od w=33u l=0.5u
M_28 XOUT net_4189 net_4201 VSS nch_25od w=33u l=0.5u
M_29 XOUT net_4189 net_4202 VSS nch_25od w=33u l=0.5u
M_30 XOUT net_4189 net_4203 VSS nch_25od w=33u l=0.5u
M_31 XOUT net_4189 net_4204 VSS nch_25od w=33u l=0.5u
M_32 net_4205 net_4206 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4207 net_4206 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4208 net_4206 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4209 net_4206 VSS VSS nch_25od w=33u l=0.5u
M_36 XOUT net_4192 net_4205 VSS nch_25od w=33u l=0.5u
M_37 XOUT net_4192 net_4207 VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4192 net_4208 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4192 net_4209 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4188 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4210 net_4193 net_4211 VSS nch_25od w=15u l=0.5u
M_53 net_4211 net_4193 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4210 net_4211 VSS nch_25od w=15u l=0.5u
M_55 net_4206 net_4196 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4194 net_4210 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4193 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4196 net_4186 VSS VSS nch_25od w=20u l=0.5u
M_59 net_4212 net_4195 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4190 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_106 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_107 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_108 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4191 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 net_4213 net_4193 VDDPST VDDPST pch_25od w=20u l=0.415u
M_112 net_4210 net_4193 net_4213 VDDPST pch_25od w=20u l=0.415u
M_113 VSS net_4210 net_4213 VDDPST pch_25od w=20u l=0.415u
M_114 XOUT net_4206 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_118 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_119 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_120 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4192 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4206 net_4196 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4194 net_4210 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4193 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4212 net_4196 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4196 net_4212 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXO02DG
.SUBCKT PDXO03DG XC XOUT XIN
M_0 VSS net_4214 net_4215 VSS nch w=3u l=0.1u
M_1 net_4214 net_4215 VDD VDD pch w=4u l=0.1u
M_2 net_4215 net_4214 net_4214 VDD pch w=4u l=0.1u
X_3 net_4216 VSS rppolywo w=1.84u l=2.76u m=1
X_4 net_4217 VSS rppolywo w=1.84u l=2.76u m=1
X_5 VDDPST net_4218 rppolywo w=1.84u l=2.76u m=1
X_6 VDDPST net_4219 rppolywo w=1.84u l=2.76u m=1
X_7 XIN net_4220 rnpolywo w=2u l=3.68u m=1
X_8 XOUT net_4221 rnpolywo w=2u l=3.68u m=1
D_9 VSS XIN ndio_esd area=643.656p
D_10 VSS XOUT ndio_esd area=559.176p
M_11 VDD net_4222 XC VDD pch w=24u l=0.09u
M_12 VSS net_4222 XC VSS nch w=9u l=0.09u
M_13 net_4223 net_4214 VSS VSS nch w=3u l=0.09u
M_14 net_4223 net_4214 VDD VDD pch w=7.5u l=0.09u
M_15 net_4224 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4225 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4226 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4227 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4228 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4229 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4230 net_4217 VSS VSS nch_25od w=33u l=0.5u
M_22 XOUT net_4217 net_4225 VSS nch_25od w=33u l=0.5u
M_23 XOUT net_4217 net_4226 VSS nch_25od w=33u l=0.5u
M_24 XOUT net_4217 net_4227 VSS nch_25od w=33u l=0.5u
M_25 XOUT net_4217 net_4228 VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4217 net_4229 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4217 net_4230 VSS nch_25od w=33u l=0.5u
M_28 net_4231 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_29 net_4233 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_30 net_4234 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_31 net_4235 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4236 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4237 net_4232 VSS VSS nch_25od w=33u l=0.5u
M_34 XOUT net_4220 net_4231 VSS nch_25od w=33u l=0.5u
M_35 XOUT net_4220 net_4233 VSS nch_25od w=33u l=0.5u
M_36 XOUT net_4220 net_4234 VSS nch_25od w=33u l=0.5u
M_37 XOUT net_4220 net_4235 VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4220 net_4236 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4220 net_4237 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4216 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4238 net_4221 net_4239 VSS nch_25od w=15u l=0.5u
M_53 net_4239 net_4221 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4238 net_4239 VSS nch_25od w=15u l=0.5u
M_55 net_4232 net_4224 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4222 net_4238 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4221 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4224 net_4214 VSS VSS nch_25od w=20u l=0.5u
M_59 net_4240 net_4223 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4218 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4219 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 net_4241 net_4221 VDDPST VDDPST pch_25od w=20u l=0.415u
M_106 net_4238 net_4221 net_4241 VDDPST pch_25od w=20u l=0.415u
M_107 VSS net_4238 net_4241 VDDPST pch_25od w=20u l=0.415u
M_108 XOUT net_4232 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_112 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_113 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_114 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_118 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_119 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_120 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4220 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4232 net_4224 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4222 net_4238 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4221 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4240 net_4224 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4224 net_4240 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXO03DG
.SUBCKT PDXOE1DG XC XOUT E XIN
M_0 VSS net_4242 net_4243 VSS nch w=3u l=0.1u
M_1 net_4242 net_4243 VDD VDD pch w=4u l=0.1u
M_2 net_4243 net_4242 net_4242 VDD pch w=4u l=0.1u
X_3 net_4244 VSS rppolywo w=1.84u l=2.76u m=1
X_4 VDDPST net_4245 rppolywo w=1.84u l=2.76u m=1
X_5 VDDPST net_4246 rppolywo w=1.84u l=2.76u m=1
X_6 net_4247 VSS rppolywo w=1.84u l=2.76u m=1
X_7 XIN net_4248 rnpolywo w=2u l=3.68u m=1
X_8 XOUT net_4249 rnpolywo w=2u l=3.68u m=1
D_9 VSS XIN ndio_esd area=643.656p
D_10 VSS XOUT ndio_esd area=559.176p
M_11 VDD net_4250 XC VDD pch w=24u l=0.09u
M_12 VSS net_4250 XC VSS nch w=9u l=0.09u
M_13 net_4251 E VSS VSS nch w=3u l=0.09u
M_14 net_4251 E VDD VDD pch w=7.5u l=0.09u
M_15 net_4252 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4253 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4254 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4255 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4256 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4257 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4258 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_22 net_4259 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_23 net_4260 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_24 net_4261 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_25 net_4262 net_4244 VSS VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4244 net_4253 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4244 net_4254 VSS nch_25od w=33u l=0.5u
M_28 XOUT net_4244 net_4255 VSS nch_25od w=33u l=0.5u
M_29 XOUT net_4244 net_4256 VSS nch_25od w=33u l=0.5u
M_30 XOUT net_4244 net_4257 VSS nch_25od w=33u l=0.5u
M_31 XOUT net_4244 net_4258 VSS nch_25od w=33u l=0.5u
M_32 XOUT net_4244 net_4259 VSS nch_25od w=33u l=0.5u
M_33 XOUT net_4244 net_4260 VSS nch_25od w=33u l=0.5u
M_34 XOUT net_4244 net_4261 VSS nch_25od w=33u l=0.5u
M_35 XOUT net_4244 net_4262 VSS nch_25od w=33u l=0.5u
M_36 net_4263 net_4264 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4265 net_4264 VSS VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4248 net_4263 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4248 net_4265 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4247 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4266 net_4249 net_4267 VSS nch_25od w=15u l=0.5u
M_53 net_4267 net_4249 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4266 net_4267 VSS nch_25od w=15u l=0.5u
M_55 net_4264 net_4252 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4250 net_4266 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4249 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4252 E VSS VSS nch_25od w=20u l=0.5u
M_59 net_4268 net_4251 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4245 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_106 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_107 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_108 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_112 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_113 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_114 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4246 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 net_4269 net_4249 VDDPST VDDPST pch_25od w=20u l=0.415u
M_118 net_4266 net_4249 net_4269 VDDPST pch_25od w=20u l=0.415u
M_119 VSS net_4266 net_4269 VDDPST pch_25od w=20u l=0.415u
M_120 XOUT net_4264 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4248 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4264 net_4252 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4250 net_4266 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4249 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4268 net_4252 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4252 net_4268 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXOE1DG
.SUBCKT PDXOE2DG XC XOUT E XIN
M_0 VSS net_4270 net_4271 VSS nch w=3u l=0.1u
M_1 net_4270 net_4271 VDD VDD pch w=4u l=0.1u
M_2 net_4271 net_4270 net_4270 VDD pch w=4u l=0.1u
X_3 XIN net_4272 rnpolywo w=2u l=3.68u m=1
X_4 XOUT net_4273 rnpolywo w=2u l=3.68u m=1
X_5 net_4274 VSS rppolywo w=1.84u l=2.76u m=1
X_6 VDDPST net_4275 rppolywo w=1.84u l=2.76u m=1
X_7 VDDPST net_4276 rppolywo w=1.84u l=2.76u m=1
X_8 net_4277 VSS rppolywo w=1.84u l=2.76u m=1
D_9 VSS XIN ndio_esd area=643.656p
D_10 VSS XOUT ndio_esd area=559.176p
M_11 VDD net_4278 XC VDD pch w=24u l=0.09u
M_12 VSS net_4278 XC VSS nch w=9u l=0.09u
M_13 net_4279 E VSS VSS nch w=3u l=0.09u
M_14 net_4279 E VDD VDD pch w=7.5u l=0.09u
M_15 net_4280 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4281 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4282 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4283 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4284 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4285 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4286 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_22 net_4287 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_23 net_4288 net_4277 VSS VSS nch_25od w=33u l=0.5u
M_24 XOUT net_4277 net_4281 VSS nch_25od w=33u l=0.5u
M_25 XOUT net_4277 net_4282 VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4277 net_4283 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4277 net_4284 VSS nch_25od w=33u l=0.5u
M_28 XOUT net_4277 net_4285 VSS nch_25od w=33u l=0.5u
M_29 XOUT net_4277 net_4286 VSS nch_25od w=33u l=0.5u
M_30 XOUT net_4277 net_4287 VSS nch_25od w=33u l=0.5u
M_31 XOUT net_4277 net_4288 VSS nch_25od w=33u l=0.5u
M_32 net_4289 net_4290 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4291 net_4290 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4292 net_4290 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4293 net_4290 VSS VSS nch_25od w=33u l=0.5u
M_36 XOUT net_4272 net_4289 VSS nch_25od w=33u l=0.5u
M_37 XOUT net_4272 net_4291 VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4272 net_4292 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4272 net_4293 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4274 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4294 net_4273 net_4295 VSS nch_25od w=15u l=0.5u
M_53 net_4295 net_4273 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4294 net_4295 VSS nch_25od w=15u l=0.5u
M_55 net_4290 net_4280 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4278 net_4294 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4273 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4280 E VSS VSS nch_25od w=20u l=0.5u
M_59 net_4296 net_4279 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4276 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_106 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_107 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_108 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4275 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 net_4297 net_4273 VDDPST VDDPST pch_25od w=20u l=0.415u
M_112 net_4294 net_4273 net_4297 VDDPST pch_25od w=20u l=0.415u
M_113 VSS net_4294 net_4297 VDDPST pch_25od w=20u l=0.415u
M_114 XOUT net_4290 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_118 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_119 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_120 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4272 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4290 net_4280 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4278 net_4294 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4273 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4296 net_4280 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4280 net_4296 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXOE2DG
.SUBCKT PDXOE3DG XC XOUT E XIN
M_0 VSS net_4298 net_4299 VSS nch w=3u l=0.1u
M_1 net_4298 net_4299 VDD VDD pch w=4u l=0.1u
M_2 net_4299 net_4298 net_4298 VDD pch w=4u l=0.1u
X_3 XIN net_4300 rnpolywo w=2u l=3.68u m=1
X_4 XOUT net_4301 rnpolywo w=2u l=3.68u m=1
X_5 net_4302 VSS rppolywo w=1.84u l=2.76u m=1
X_6 VDDPST net_4303 rppolywo w=1.84u l=2.76u m=1
X_7 VDDPST net_4304 rppolywo w=1.84u l=2.76u m=1
X_8 net_4305 VSS rppolywo w=1.84u l=2.76u m=1
D_9 VSS XIN ndio_esd area=643.656p
D_10 VSS XOUT ndio_esd area=559.176p
M_11 VDD net_4306 XC VDD pch w=24u l=0.09u
M_12 VSS net_4306 XC VSS nch w=9u l=0.09u
M_13 net_4307 E VSS VSS nch w=3u l=0.09u
M_14 net_4307 E VDD VDD pch w=7.5u l=0.09u
M_15 net_4308 POC VSS VSS nch_25od w=3u l=0.5u
M_16 net_4309 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_17 net_4310 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_18 net_4311 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_19 net_4312 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_20 net_4313 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_21 net_4314 net_4305 VSS VSS nch_25od w=33u l=0.5u
M_22 XOUT net_4305 net_4309 VSS nch_25od w=33u l=0.5u
M_23 XOUT net_4305 net_4310 VSS nch_25od w=33u l=0.5u
M_24 XOUT net_4305 net_4311 VSS nch_25od w=33u l=0.5u
M_25 XOUT net_4305 net_4312 VSS nch_25od w=33u l=0.5u
M_26 XOUT net_4305 net_4313 VSS nch_25od w=33u l=0.5u
M_27 XOUT net_4305 net_4314 VSS nch_25od w=33u l=0.5u
M_28 net_4315 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_29 net_4317 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_30 net_4318 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_31 net_4319 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4320 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4321 net_4316 VSS VSS nch_25od w=33u l=0.5u
M_34 XOUT net_4300 net_4315 VSS nch_25od w=33u l=0.5u
M_35 XOUT net_4300 net_4317 VSS nch_25od w=33u l=0.5u
M_36 XOUT net_4300 net_4318 VSS nch_25od w=33u l=0.5u
M_37 XOUT net_4300 net_4319 VSS nch_25od w=33u l=0.5u
M_38 XOUT net_4300 net_4320 VSS nch_25od w=33u l=0.5u
M_39 XOUT net_4300 net_4321 VSS nch_25od w=33u l=0.5u
M_40 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_41 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_42 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_43 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_44 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_45 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_46 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_47 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_48 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_49 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_50 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_51 XIN net_4302 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4322 net_4301 net_4323 VSS nch_25od w=15u l=0.5u
M_53 net_4323 net_4301 VSS VSS nch_25od w=15u l=0.5u
M_54 VDDPST net_4322 net_4323 VSS nch_25od w=15u l=0.5u
M_55 net_4316 net_4308 VSS VSS nch_25od w=10u l=0.5u
M_56 net_4306 net_4322 VSS VSS nch_25od w=3u l=0.5u
M_57 net_4301 VSS VSS VSS nch_25od w=20u l=0.5u
M_58 net_4308 E VSS VSS nch_25od w=20u l=0.5u
M_59 net_4324 net_4307 VSS VSS nch_25od w=20u l=0.5u
M_60 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_61 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_62 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_63 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_64 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_65 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_66 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_67 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_68 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_69 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_70 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_71 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_72 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_73 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_74 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_75 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_76 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_77 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_78 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_79 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_80 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_81 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_82 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_83 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_84 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_85 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_86 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_87 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_88 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_89 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_90 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_91 XIN net_4304 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_92 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_93 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_94 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_95 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_96 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_97 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_98 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_99 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_100 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_101 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_102 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_103 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_104 XOUT net_4303 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_105 net_4325 net_4301 VDDPST VDDPST pch_25od w=20u l=0.415u
M_106 net_4322 net_4301 net_4325 VDDPST pch_25od w=20u l=0.415u
M_107 VSS net_4322 net_4325 VDDPST pch_25od w=20u l=0.415u
M_108 XOUT net_4316 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_109 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_110 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_111 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_112 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_113 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_114 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_115 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_116 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_117 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_118 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_119 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_120 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_121 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_122 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_123 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_124 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_125 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_126 XOUT net_4300 VDDPST VDDPST pch_25od w=16.5u l=0.415u
M_127 net_4316 net_4308 VDDPST VDDPST pch_25od w=30u l=0.415u
M_128 net_4306 net_4322 VDD VDD pch_25od w=18u l=0.415u
M_129 net_4301 VDDPST VDDPST VDDPST pch_25od w=20u l=0.415u
M_130 net_4324 net_4308 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4308 net_4324 VDDPST VDDPST pch_25od w=0.5u l=1u
*PGATE NGATE
.ENDS PDXOE3DG
.SUBCKT PRB08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4326 net_4327 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4328 net_4328 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4327 net_4329 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4330 net_4326 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4331 net_4330 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4332 net_4332 rppolywo w=0.4u l=1.3u m=1
X_14 net_4333 net_4333 rppolywo w=0.4u l=1.3u m=1
X_15 net_4334 net_4334 rppolywo w=0.4u l=1.3u m=1
X_16 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_17 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_18 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_19 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_20 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_21 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_22 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_23 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_24 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_25 net_4335 net_4335 rppolywo w=0.4u l=1.3u m=1
X_26 net_4336 net_4332 rppolywo w=0.4u l=1.3u m=1
X_27 net_4332 net_4333 rppolywo w=0.4u l=1.3u m=1
X_28 net_4333 net_4334 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4337 net_4338 VSS nch_25od w=33u l=0.5u
M_30 PAD net_4337 net_4339 VSS nch_25od w=33u l=0.5u
M_31 net_4339 net_4330 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4338 net_4327 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4340 net_4326 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4341 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4342 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4343 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4344 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4345 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4346 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4347 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4348 net_4328 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_4337 net_4341 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4337 net_4342 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4337 net_4343 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4337 net_4344 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4337 net_4345 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4337 net_4346 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4337 net_4347 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4337 net_4348 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4337 net_4340 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4337 net_4349 VSS nch_25od w=33u l=0.5u
M_52 net_4349 net_4329 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4332 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_54 PAD net_4332 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_55 PAD net_4332 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_56 PAD net_4332 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_57 PAD net_4333 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_58 PAD net_4333 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_59 PAD net_4333 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_60 PAD net_4333 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_61 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_62 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_63 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_64 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_65 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_66 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_67 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_68 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_69 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_70 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_71 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_72 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_73 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_74 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_75 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_76 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_77 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_78 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_79 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_80 PAD net_4335 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_81 PAD net_4334 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_82 PAD net_4334 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_83 PAD net_4334 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_84 PAD net_4334 VDDPST net_4335 pch_25od w=16.5u l=0.415u
M_85 VSS net_4350 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4335 net_4335 net_4335 net_4335 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4351 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4352 net_4353 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4354 net_4353 net_4352 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4354 net_4353 net_4355 VDDPST pch_25od w=5u l=0.415u
M_93 net_4355 net_4356 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4357 net_4358 net_4331 VDDPST pch_25od w=20u l=0.415u
M_95 net_4357 net_4359 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4331 net_4359 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4358 net_4331 VSS nch_25od w=15u l=0.5u
M_98 net_4360 net_4361 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4362 net_4363 net_4364 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4365 VSS nch_25od w=10u l=0.5u
M_101 net_4366 net_4363 net_4367 VSS nch_25od w=10u l=0.5u
M_102 net_4365 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4365 net_4360 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4365 net_4360 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4367 VSS nch w=10u l=0.09u
M_106 net_4362 net_4361 VSS VSS nch w=10u l=0.09u
M_107 net_4366 I net_4365 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4360 net_4361 net_4364 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4368 net_4369 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4370 net_4363 net_4371 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4372 VSS nch_25od w=10u l=0.5u
M_112 net_4373 net_4363 net_4374 VSS nch_25od w=10u l=0.5u
M_113 net_4372 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4372 net_4368 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4372 net_4368 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4374 VSS nch w=10u l=0.09u
M_117 net_4370 net_4369 VSS VSS nch w=10u l=0.09u
M_118 net_4373 OEN net_4372 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4368 net_4369 net_4371 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4375 net_4376 VDDPST pch_25od w=40u l=0.415u
M_121 net_4376 net_4377 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4378 net_4375 net_4376 VSS nch_25od w=20u l=0.5u
M_123 net_4378 net_4377 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4379 net_4380 VSS nch w=3u l=0.1u
M_125 net_4379 net_4380 VDD VDD pch w=4u l=0.1u
M_126 net_4380 net_4379 net_4379 VDD pch w=4u l=0.1u
M_127 net_4350 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4351 net_4381 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4350 net_4379 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4350 net_4351 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4351 net_4350 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4363 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4363 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4356 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4328 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4382 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4337 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4379 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4383 net_4360 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4383 net_4360 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4377 net_4368 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4377 net_4368 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4358 net_4365 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4358 net_4365 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4375 net_4383 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4375 net_4383 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4359 net_4372 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4359 net_4372 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4361 I VSS VSS nch w=3u l=0.09u
M_152 net_4361 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4369 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4369 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4381 net_4379 VSS VSS nch w=3u l=0.09u
M_156 net_4381 net_4379 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4384 C VSS nch w=20u l=0.09u
M_158 VSS net_4385 net_4384 VSS nch w=10u l=0.09u
M_159 VDD net_4384 C VDD pch w=30u l=0.09u
M_160 VDD net_4385 net_4384 VDD pch w=10u l=0.09u
M_161 VSS net_4354 net_4386 VSS nch_25od w=0.6u l=0.5u
M_162 net_4385 net_4386 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4387 net_4377 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4388 net_4382 net_4387 VSS nch_25od w=10u l=0.5u
M_165 net_4336 net_4382 net_4376 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4354 net_4385 VSS nch_25od w=5u l=0.5u
M_167 net_4356 net_4382 net_4353 VSS nch_25od w=30u l=0.5u
M_168 net_4389 net_4382 net_4388 VSS nch_25od w=10u l=0.5u
M_169 net_4353 net_4359 net_4389 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4354 net_4386 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4388 net_4382 net_4356 net_4335 pch_25od w=26u l=0.415u
M_172 net_4336 net_4388 net_4376 net_4335 pch_25od w=26u l=0.415u
M_173 VDD net_4354 net_4385 VDD pch_25od w=5u l=0.415u
M_174 net_4335 net_4388 VDDPST net_4335 pch_25od w=24u l=0.415u
M_175 net_4335 net_4382 net_4356 net_4335 pch_25od w=24u l=0.415u
M_176 net_4336 net_4382 net_4356 net_4335 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB08DGZ
.SUBCKT PRB08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4390 net_4391 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4392 net_4392 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4391 net_4393 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4394 net_4390 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4395 net_4394 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4396 net_4396 rppolywo w=0.4u l=1.3u m=1
X_14 net_4397 net_4397 rppolywo w=0.4u l=1.3u m=1
X_15 net_4398 net_4398 rppolywo w=0.4u l=1.3u m=1
X_16 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_17 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_18 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_19 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_20 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_21 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_22 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_23 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_24 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_25 net_4399 net_4399 rppolywo w=0.4u l=1.3u m=1
X_26 net_4400 net_4396 rppolywo w=0.4u l=1.3u m=1
X_27 net_4396 net_4397 rppolywo w=0.4u l=1.3u m=1
X_28 net_4397 net_4398 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4401 net_4402 VSS nch_25od w=33u l=0.5u
M_30 PAD net_4401 net_4403 VSS nch_25od w=33u l=0.5u
M_31 net_4403 net_4394 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4402 net_4391 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4404 net_4390 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4405 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4406 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4407 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4408 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4409 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4410 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4411 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4412 net_4392 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_4401 net_4405 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4401 net_4406 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4401 net_4407 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4401 net_4408 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4401 net_4409 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4401 net_4410 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4401 net_4411 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4401 net_4412 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4401 net_4404 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4401 net_4413 VSS nch_25od w=33u l=0.5u
M_52 net_4413 net_4393 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4396 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_54 PAD net_4396 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_55 PAD net_4396 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_56 PAD net_4396 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_57 PAD net_4397 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_58 PAD net_4397 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_59 PAD net_4397 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_60 PAD net_4397 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_61 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_62 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_63 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_64 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_65 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_66 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_67 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_68 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_69 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_70 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_71 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_72 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_73 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_74 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_75 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_76 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_77 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_78 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_79 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_80 PAD net_4399 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_81 PAD net_4398 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_82 PAD net_4398 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_83 PAD net_4398 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_84 PAD net_4398 VDDPST net_4399 pch_25od w=16.5u l=0.415u
M_85 VSS net_4414 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4399 net_4399 net_4399 net_4399 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4415 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_4416 net_4417 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_4416 net_4418 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4417 net_4418 net_4416 VSS nch_25od w=5u l=0.5u
M_91 net_4419 net_4417 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4417 net_4418 net_4419 VDDPST pch_25od w=5u l=0.415u
M_93 net_4419 net_4420 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4421 net_4422 net_4395 VDDPST pch_25od w=20u l=0.415u
M_95 net_4421 net_4423 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4395 net_4423 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4422 net_4395 VSS nch_25od w=15u l=0.5u
M_98 net_4424 net_4425 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4426 net_4427 net_4428 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4429 VSS nch_25od w=10u l=0.5u
M_101 net_4430 net_4427 net_4431 VSS nch_25od w=10u l=0.5u
M_102 net_4429 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4429 net_4424 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4429 net_4424 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4431 VSS nch w=10u l=0.09u
M_106 net_4426 net_4425 VSS VSS nch w=10u l=0.09u
M_107 net_4430 I net_4429 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4424 net_4425 net_4428 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4432 net_4433 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4434 net_4427 net_4435 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4436 VSS nch_25od w=10u l=0.5u
M_112 net_4437 net_4427 net_4438 VSS nch_25od w=10u l=0.5u
M_113 net_4436 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4436 net_4432 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4436 net_4432 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4438 VSS nch w=10u l=0.09u
M_117 net_4434 net_4433 VSS VSS nch w=10u l=0.09u
M_118 net_4437 OEN net_4436 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4432 net_4433 net_4435 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4439 net_4440 VDDPST pch_25od w=40u l=0.415u
M_121 net_4440 net_4441 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4442 net_4439 net_4440 VSS nch_25od w=20u l=0.5u
M_123 net_4442 net_4441 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4443 net_4444 VSS nch w=3u l=0.1u
M_125 net_4443 net_4444 VDD VDD pch w=4u l=0.1u
M_126 net_4444 net_4443 net_4443 VDD pch w=4u l=0.1u
M_127 net_4414 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4415 net_4445 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4414 net_4443 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4414 net_4415 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4415 net_4414 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4427 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4427 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4420 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4392 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4446 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4401 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4443 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4447 net_4424 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4447 net_4424 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4441 net_4432 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4441 net_4432 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4422 net_4429 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4422 net_4429 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4439 net_4447 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4439 net_4447 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4423 net_4436 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4423 net_4436 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4425 I VSS VSS nch w=3u l=0.09u
M_152 net_4425 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4433 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4433 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4445 net_4443 VSS VSS nch w=3u l=0.09u
M_156 net_4445 net_4443 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4448 C VSS nch w=20u l=0.09u
M_158 VSS net_4449 net_4448 VSS nch w=10u l=0.09u
M_159 VDD net_4448 C VDD pch w=30u l=0.09u
M_160 VDD net_4449 net_4448 VDD pch w=10u l=0.09u
M_161 VSS net_4417 net_4450 VSS nch_25od w=0.6u l=0.5u
M_162 net_4449 net_4450 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4451 net_4441 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4452 net_4446 net_4451 VSS nch_25od w=10u l=0.5u
M_165 net_4400 net_4446 net_4440 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4417 net_4449 VSS nch_25od w=5u l=0.5u
M_167 net_4420 net_4446 net_4418 VSS nch_25od w=30u l=0.5u
M_168 net_4453 net_4446 net_4452 VSS nch_25od w=10u l=0.5u
M_169 net_4418 net_4423 net_4453 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4417 net_4450 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4452 net_4446 net_4420 net_4399 pch_25od w=26u l=0.415u
M_172 net_4400 net_4452 net_4440 net_4399 pch_25od w=26u l=0.415u
M_173 VDD net_4417 net_4449 VDD pch_25od w=5u l=0.415u
M_174 net_4399 net_4452 VDDPST net_4399 pch_25od w=24u l=0.415u
M_175 net_4399 net_4446 net_4420 net_4399 pch_25od w=24u l=0.415u
M_176 net_4400 net_4446 net_4420 net_4399 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB08SDGZ
.SUBCKT PRB12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4454 net_4455 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4456 net_4457 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4458 net_4459 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4459 net_4460 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4461 net_4461 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4455 net_4458 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4457 net_4454 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4462 net_4462 rppolywo w=0.4u l=1.3u m=1
X_14 net_4462 net_4462 rppolywo w=0.4u l=1.3u m=1
X_15 net_4463 net_4463 rppolywo w=0.4u l=1.3u m=1
X_16 net_4463 net_4463 rppolywo w=0.4u l=1.3u m=1
X_17 net_4464 net_4464 rppolywo w=0.4u l=1.3u m=1
X_18 net_4464 net_4464 rppolywo w=0.4u l=1.3u m=1
X_19 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_20 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_21 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_22 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_23 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_24 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_25 net_4465 net_4465 rppolywo w=0.4u l=1.3u m=1
X_26 net_4466 net_4462 rppolywo w=0.4u l=1.3u m=1
X_27 net_4462 net_4463 rppolywo w=0.4u l=1.3u m=1
X_28 net_4463 net_4464 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4467 net_4468 VSS nch_25od w=33u l=0.5u
M_30 net_4469 net_4458 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_4467 net_4469 VSS nch_25od w=33u l=0.5u
M_32 net_4468 net_4457 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_4467 net_4470 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4467 net_4471 VSS nch_25od w=33u l=0.5u
M_35 net_4471 net_4455 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_4467 net_4472 VSS nch_25od w=33u l=0.5u
M_37 net_4470 net_4459 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4472 net_4454 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4473 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4474 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4475 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_42 net_4476 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_43 net_4477 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_44 net_4478 net_4461 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_4467 net_4473 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4467 net_4474 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4467 net_4475 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4467 net_4476 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4467 net_4477 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4467 net_4478 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4467 net_4479 VSS nch_25od w=33u l=0.5u
M_52 net_4479 net_4460 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_54 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_55 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_56 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_57 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_58 PAD net_4462 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_59 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_60 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_61 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_62 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_63 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_64 PAD net_4463 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_65 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_66 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_67 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_68 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_69 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_70 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_71 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_72 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_73 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_74 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_75 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_76 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_77 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_78 PAD net_4465 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_79 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_80 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_81 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_82 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_83 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_84 PAD net_4464 VDDPST net_4465 pch_25od w=16.5u l=0.415u
M_85 VSS net_4480 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4465 net_4465 net_4465 net_4465 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4481 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4482 net_4483 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4484 net_4483 net_4482 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4484 net_4483 net_4485 VDDPST pch_25od w=5u l=0.415u
M_93 net_4485 net_4486 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4487 net_4488 net_4456 VDDPST pch_25od w=20u l=0.415u
M_95 net_4487 net_4489 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4456 net_4489 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4488 net_4456 VSS nch_25od w=15u l=0.5u
M_98 net_4490 net_4491 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4492 net_4493 net_4494 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4495 VSS nch_25od w=10u l=0.5u
M_101 net_4496 net_4493 net_4497 VSS nch_25od w=10u l=0.5u
M_102 net_4495 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4495 net_4490 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4495 net_4490 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4497 VSS nch w=10u l=0.09u
M_106 net_4492 net_4491 VSS VSS nch w=10u l=0.09u
M_107 net_4496 I net_4495 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4490 net_4491 net_4494 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4498 net_4499 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4500 net_4493 net_4501 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4502 VSS nch_25od w=10u l=0.5u
M_112 net_4503 net_4493 net_4504 VSS nch_25od w=10u l=0.5u
M_113 net_4502 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4502 net_4498 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4502 net_4498 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4504 VSS nch w=10u l=0.09u
M_117 net_4500 net_4499 VSS VSS nch w=10u l=0.09u
M_118 net_4503 OEN net_4502 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4498 net_4499 net_4501 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4505 net_4506 VDDPST pch_25od w=40u l=0.415u
M_121 net_4506 net_4507 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4508 net_4505 net_4506 VSS nch_25od w=20u l=0.5u
M_123 net_4508 net_4507 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4509 net_4510 VSS nch w=3u l=0.1u
M_125 net_4509 net_4510 VDD VDD pch w=4u l=0.1u
M_126 net_4510 net_4509 net_4509 VDD pch w=4u l=0.1u
M_127 net_4480 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4481 net_4511 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4480 net_4509 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4480 net_4481 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4481 net_4480 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4493 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4493 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4486 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4461 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4512 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4467 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4509 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4513 net_4490 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4513 net_4490 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4507 net_4498 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4507 net_4498 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4488 net_4495 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4488 net_4495 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4505 net_4513 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4505 net_4513 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4489 net_4502 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4489 net_4502 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4491 I VSS VSS nch w=3u l=0.09u
M_152 net_4491 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4499 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4499 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4511 net_4509 VSS VSS nch w=3u l=0.09u
M_156 net_4511 net_4509 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4514 C VSS nch w=20u l=0.09u
M_158 VSS net_4515 net_4514 VSS nch w=10u l=0.09u
M_159 VDD net_4514 C VDD pch w=30u l=0.09u
M_160 VDD net_4515 net_4514 VDD pch w=10u l=0.09u
M_161 VSS net_4484 net_4516 VSS nch_25od w=0.6u l=0.5u
M_162 net_4515 net_4516 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4517 net_4507 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4518 net_4512 net_4517 VSS nch_25od w=10u l=0.5u
M_165 net_4466 net_4512 net_4506 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4484 net_4515 VSS nch_25od w=5u l=0.5u
M_167 net_4486 net_4512 net_4483 VSS nch_25od w=30u l=0.5u
M_168 net_4519 net_4512 net_4518 VSS nch_25od w=10u l=0.5u
M_169 net_4483 net_4489 net_4519 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4484 net_4516 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4518 net_4512 net_4486 net_4465 pch_25od w=26u l=0.415u
M_172 net_4466 net_4518 net_4506 net_4465 pch_25od w=26u l=0.415u
M_173 VDD net_4484 net_4515 VDD pch_25od w=5u l=0.415u
M_174 net_4465 net_4518 VDDPST net_4465 pch_25od w=24u l=0.415u
M_175 net_4465 net_4512 net_4486 net_4465 pch_25od w=24u l=0.415u
M_176 net_4466 net_4512 net_4486 net_4465 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB12DGZ
.SUBCKT PRB12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4520 net_4521 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4522 net_4523 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4524 net_4525 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4525 net_4526 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4527 net_4527 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4521 net_4524 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4523 net_4520 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4528 net_4528 rppolywo w=0.4u l=1.3u m=1
X_14 net_4528 net_4528 rppolywo w=0.4u l=1.3u m=1
X_15 net_4529 net_4529 rppolywo w=0.4u l=1.3u m=1
X_16 net_4529 net_4529 rppolywo w=0.4u l=1.3u m=1
X_17 net_4530 net_4530 rppolywo w=0.4u l=1.3u m=1
X_18 net_4530 net_4530 rppolywo w=0.4u l=1.3u m=1
X_19 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_20 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_21 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_22 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_23 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_24 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_25 net_4531 net_4531 rppolywo w=0.4u l=1.3u m=1
X_26 net_4532 net_4528 rppolywo w=0.4u l=1.3u m=1
X_27 net_4528 net_4529 rppolywo w=0.4u l=1.3u m=1
X_28 net_4529 net_4530 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4533 net_4534 VSS nch_25od w=33u l=0.5u
M_30 net_4535 net_4524 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_4533 net_4535 VSS nch_25od w=33u l=0.5u
M_32 net_4534 net_4523 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_4533 net_4536 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4533 net_4537 VSS nch_25od w=33u l=0.5u
M_35 net_4537 net_4521 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_4533 net_4538 VSS nch_25od w=33u l=0.5u
M_37 net_4536 net_4525 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4538 net_4520 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4539 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4540 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4541 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_42 net_4542 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_43 net_4543 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_44 net_4544 net_4527 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_4533 net_4539 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4533 net_4540 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4533 net_4541 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4533 net_4542 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4533 net_4543 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4533 net_4544 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4533 net_4545 VSS nch_25od w=33u l=0.5u
M_52 net_4545 net_4526 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_54 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_55 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_56 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_57 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_58 PAD net_4528 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_59 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_60 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_61 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_62 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_63 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_64 PAD net_4529 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_65 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_66 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_67 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_68 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_69 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_70 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_71 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_72 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_73 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_74 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_75 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_76 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_77 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_78 PAD net_4531 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_79 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_80 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_81 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_82 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_83 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_84 PAD net_4530 VDDPST net_4531 pch_25od w=16.5u l=0.415u
M_85 VSS net_4546 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4531 net_4531 net_4531 net_4531 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4547 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_4548 net_4549 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_4548 net_4550 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4549 net_4550 net_4548 VSS nch_25od w=5u l=0.5u
M_91 net_4551 net_4549 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4549 net_4550 net_4551 VDDPST pch_25od w=5u l=0.415u
M_93 net_4551 net_4552 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4553 net_4554 net_4522 VDDPST pch_25od w=20u l=0.415u
M_95 net_4553 net_4555 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4522 net_4555 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4554 net_4522 VSS nch_25od w=15u l=0.5u
M_98 net_4556 net_4557 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4558 net_4559 net_4560 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4561 VSS nch_25od w=10u l=0.5u
M_101 net_4562 net_4559 net_4563 VSS nch_25od w=10u l=0.5u
M_102 net_4561 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4561 net_4556 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4561 net_4556 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4563 VSS nch w=10u l=0.09u
M_106 net_4558 net_4557 VSS VSS nch w=10u l=0.09u
M_107 net_4562 I net_4561 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4556 net_4557 net_4560 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4564 net_4565 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4566 net_4559 net_4567 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4568 VSS nch_25od w=10u l=0.5u
M_112 net_4569 net_4559 net_4570 VSS nch_25od w=10u l=0.5u
M_113 net_4568 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4568 net_4564 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4568 net_4564 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4570 VSS nch w=10u l=0.09u
M_117 net_4566 net_4565 VSS VSS nch w=10u l=0.09u
M_118 net_4569 OEN net_4568 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4564 net_4565 net_4567 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4571 net_4572 VDDPST pch_25od w=40u l=0.415u
M_121 net_4572 net_4573 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4574 net_4571 net_4572 VSS nch_25od w=20u l=0.5u
M_123 net_4574 net_4573 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4575 net_4576 VSS nch w=3u l=0.1u
M_125 net_4575 net_4576 VDD VDD pch w=4u l=0.1u
M_126 net_4576 net_4575 net_4575 VDD pch w=4u l=0.1u
M_127 net_4546 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4547 net_4577 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4546 net_4575 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4546 net_4547 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4547 net_4546 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4559 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4559 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4552 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4527 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4578 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4533 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4575 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4579 net_4556 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4579 net_4556 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4573 net_4564 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4573 net_4564 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4554 net_4561 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4554 net_4561 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4571 net_4579 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4571 net_4579 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4555 net_4568 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4555 net_4568 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4557 I VSS VSS nch w=3u l=0.09u
M_152 net_4557 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4565 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4565 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4577 net_4575 VSS VSS nch w=3u l=0.09u
M_156 net_4577 net_4575 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4580 C VSS nch w=20u l=0.09u
M_158 VSS net_4581 net_4580 VSS nch w=10u l=0.09u
M_159 VDD net_4580 C VDD pch w=30u l=0.09u
M_160 VDD net_4581 net_4580 VDD pch w=10u l=0.09u
M_161 VSS net_4549 net_4582 VSS nch_25od w=0.6u l=0.5u
M_162 net_4581 net_4582 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4583 net_4573 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4584 net_4578 net_4583 VSS nch_25od w=10u l=0.5u
M_165 net_4532 net_4578 net_4572 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4549 net_4581 VSS nch_25od w=5u l=0.5u
M_167 net_4552 net_4578 net_4550 VSS nch_25od w=30u l=0.5u
M_168 net_4585 net_4578 net_4584 VSS nch_25od w=10u l=0.5u
M_169 net_4550 net_4555 net_4585 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4549 net_4582 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4584 net_4578 net_4552 net_4531 pch_25od w=26u l=0.415u
M_172 net_4532 net_4584 net_4572 net_4531 pch_25od w=26u l=0.415u
M_173 VDD net_4549 net_4581 VDD pch_25od w=5u l=0.415u
M_174 net_4531 net_4584 VDDPST net_4531 pch_25od w=24u l=0.415u
M_175 net_4531 net_4578 net_4552 net_4531 pch_25od w=24u l=0.415u
M_176 net_4532 net_4578 net_4552 net_4531 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB12SDGZ
.SUBCKT PRB16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4586 net_4587 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4588 net_4589 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4590 net_4590 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4590 net_4590 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4590 net_4590 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4590 net_4590 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4591 net_4592 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4592 net_4593 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4593 net_4593 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4592 net_4592 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4587 net_4591 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4589 net_4586 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4594 net_4594 rppolywo w=0.4u l=1.3u m=1
X_14 net_4594 net_4594 rppolywo w=0.4u l=1.3u m=1
X_15 net_4594 net_4594 rppolywo w=0.4u l=1.3u m=1
X_16 net_4595 net_4595 rppolywo w=0.4u l=1.3u m=1
X_17 net_4595 net_4595 rppolywo w=0.4u l=1.3u m=1
X_18 net_4595 net_4595 rppolywo w=0.4u l=1.3u m=1
X_19 net_4596 net_4596 rppolywo w=0.4u l=1.3u m=1
X_20 net_4596 net_4596 rppolywo w=0.4u l=1.3u m=1
X_21 net_4596 net_4596 rppolywo w=0.4u l=1.3u m=1
X_22 net_4597 net_4597 rppolywo w=0.4u l=1.3u m=1
X_23 net_4597 net_4597 rppolywo w=0.4u l=1.3u m=1
X_24 net_4597 net_4597 rppolywo w=0.4u l=1.3u m=1
X_25 net_4597 net_4597 rppolywo w=0.4u l=1.3u m=1
X_26 net_4598 net_4595 rppolywo w=0.4u l=1.3u m=1
X_27 net_4595 net_4594 rppolywo w=0.4u l=1.3u m=1
X_28 net_4594 net_4596 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4599 net_4600 VSS nch_25od w=33u l=0.5u
M_30 net_4601 net_4591 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_4599 net_4601 VSS nch_25od w=33u l=0.5u
M_32 net_4600 net_4589 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_4599 net_4602 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4599 net_4603 VSS nch_25od w=33u l=0.5u
M_35 PAD net_4599 net_4604 VSS nch_25od w=33u l=0.5u
M_36 net_4604 net_4587 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_4599 net_4605 VSS nch_25od w=33u l=0.5u
M_38 net_4602 net_4592 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4603 net_4592 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4605 net_4586 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4606 net_4590 VSS VSS nch_25od w=33u l=0.5u
M_42 net_4607 net_4590 VSS VSS nch_25od w=33u l=0.5u
M_43 net_4608 net_4590 VSS VSS nch_25od w=33u l=0.5u
M_44 net_4609 net_4590 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_4599 net_4606 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4599 net_4607 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4599 net_4608 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4599 net_4609 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4599 net_4610 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4599 net_4611 VSS nch_25od w=33u l=0.5u
M_51 net_4610 net_4593 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4611 net_4593 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_54 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_55 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_56 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_57 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_58 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_59 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_60 PAD net_4594 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_61 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_62 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_63 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_64 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_65 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_66 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_67 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_68 PAD net_4595 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_69 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_70 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_71 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_72 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_73 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_74 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_75 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_76 PAD net_4597 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_77 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_78 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_79 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_80 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_81 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_82 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_83 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_84 PAD net_4596 VDDPST net_4597 pch_25od w=16.5u l=0.415u
M_85 VSS net_4612 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4597 net_4597 net_4597 net_4597 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4613 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4614 net_4615 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4616 net_4615 net_4614 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4616 net_4615 net_4617 VDDPST pch_25od w=5u l=0.415u
M_93 net_4617 net_4618 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4619 net_4620 net_4588 VDDPST pch_25od w=20u l=0.415u
M_95 net_4619 net_4621 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4588 net_4621 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4620 net_4588 VSS nch_25od w=15u l=0.5u
M_98 net_4622 net_4623 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4624 net_4625 net_4626 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4627 VSS nch_25od w=10u l=0.5u
M_101 net_4628 net_4625 net_4629 VSS nch_25od w=10u l=0.5u
M_102 net_4627 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4627 net_4622 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4627 net_4622 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4629 VSS nch w=10u l=0.09u
M_106 net_4624 net_4623 VSS VSS nch w=10u l=0.09u
M_107 net_4628 I net_4627 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4622 net_4623 net_4626 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4630 net_4631 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4632 net_4625 net_4633 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4634 VSS nch_25od w=10u l=0.5u
M_112 net_4635 net_4625 net_4636 VSS nch_25od w=10u l=0.5u
M_113 net_4634 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4634 net_4630 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4634 net_4630 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4636 VSS nch w=10u l=0.09u
M_117 net_4632 net_4631 VSS VSS nch w=10u l=0.09u
M_118 net_4635 OEN net_4634 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4630 net_4631 net_4633 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4637 net_4638 VDDPST pch_25od w=40u l=0.415u
M_121 net_4638 net_4639 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4640 net_4637 net_4638 VSS nch_25od w=20u l=0.5u
M_123 net_4640 net_4639 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4641 net_4642 VSS nch w=3u l=0.1u
M_125 net_4641 net_4642 VDD VDD pch w=4u l=0.1u
M_126 net_4642 net_4641 net_4641 VDD pch w=4u l=0.1u
M_127 net_4612 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4613 net_4643 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4612 net_4641 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4612 net_4613 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4613 net_4612 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4625 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4625 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4618 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4590 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4644 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4599 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4641 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4645 net_4622 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4645 net_4622 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4639 net_4630 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4639 net_4630 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4620 net_4627 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4620 net_4627 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4637 net_4645 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4637 net_4645 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4621 net_4634 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4621 net_4634 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4623 I VSS VSS nch w=3u l=0.09u
M_152 net_4623 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4631 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4631 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4643 net_4641 VSS VSS nch w=3u l=0.09u
M_156 net_4643 net_4641 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4646 C VSS nch w=20u l=0.09u
M_158 VSS net_4647 net_4646 VSS nch w=10u l=0.09u
M_159 VDD net_4646 C VDD pch w=30u l=0.09u
M_160 VDD net_4647 net_4646 VDD pch w=10u l=0.09u
M_161 VSS net_4616 net_4648 VSS nch_25od w=0.6u l=0.5u
M_162 net_4647 net_4648 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4649 net_4639 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4650 net_4644 net_4649 VSS nch_25od w=10u l=0.5u
M_165 net_4598 net_4644 net_4638 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4616 net_4647 VSS nch_25od w=5u l=0.5u
M_167 net_4618 net_4644 net_4615 VSS nch_25od w=30u l=0.5u
M_168 net_4651 net_4644 net_4650 VSS nch_25od w=10u l=0.5u
M_169 net_4615 net_4621 net_4651 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4616 net_4648 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4650 net_4644 net_4618 net_4597 pch_25od w=26u l=0.415u
M_172 net_4598 net_4650 net_4638 net_4597 pch_25od w=26u l=0.415u
M_173 VDD net_4616 net_4647 VDD pch_25od w=5u l=0.415u
M_174 net_4597 net_4650 VDDPST net_4597 pch_25od w=24u l=0.415u
M_175 net_4597 net_4644 net_4618 net_4597 pch_25od w=24u l=0.415u
M_176 net_4598 net_4644 net_4618 net_4597 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB16DGZ
.SUBCKT PRB16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4652 net_4653 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4654 net_4655 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4656 net_4656 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4656 net_4656 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4656 net_4656 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4656 net_4656 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4657 net_4658 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4658 net_4659 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4659 net_4659 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4658 net_4658 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4653 net_4657 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4655 net_4652 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4660 net_4660 rppolywo w=0.4u l=1.3u m=1
X_14 net_4660 net_4660 rppolywo w=0.4u l=1.3u m=1
X_15 net_4660 net_4660 rppolywo w=0.4u l=1.3u m=1
X_16 net_4661 net_4661 rppolywo w=0.4u l=1.3u m=1
X_17 net_4661 net_4661 rppolywo w=0.4u l=1.3u m=1
X_18 net_4661 net_4661 rppolywo w=0.4u l=1.3u m=1
X_19 net_4662 net_4662 rppolywo w=0.4u l=1.3u m=1
X_20 net_4662 net_4662 rppolywo w=0.4u l=1.3u m=1
X_21 net_4662 net_4662 rppolywo w=0.4u l=1.3u m=1
X_22 net_4663 net_4663 rppolywo w=0.4u l=1.3u m=1
X_23 net_4663 net_4663 rppolywo w=0.4u l=1.3u m=1
X_24 net_4663 net_4663 rppolywo w=0.4u l=1.3u m=1
X_25 net_4663 net_4663 rppolywo w=0.4u l=1.3u m=1
X_26 net_4664 net_4661 rppolywo w=0.4u l=1.3u m=1
X_27 net_4661 net_4660 rppolywo w=0.4u l=1.3u m=1
X_28 net_4660 net_4662 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4665 net_4666 VSS nch_25od w=33u l=0.5u
M_30 net_4667 net_4657 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_4665 net_4667 VSS nch_25od w=33u l=0.5u
M_32 net_4666 net_4655 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_4665 net_4668 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4665 net_4669 VSS nch_25od w=33u l=0.5u
M_35 PAD net_4665 net_4670 VSS nch_25od w=33u l=0.5u
M_36 net_4670 net_4653 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_4665 net_4671 VSS nch_25od w=33u l=0.5u
M_38 net_4668 net_4658 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4669 net_4658 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4671 net_4652 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4672 net_4656 VSS VSS nch_25od w=33u l=0.5u
M_42 net_4673 net_4656 VSS VSS nch_25od w=33u l=0.5u
M_43 net_4674 net_4656 VSS VSS nch_25od w=33u l=0.5u
M_44 net_4675 net_4656 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_4665 net_4672 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4665 net_4673 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4665 net_4674 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4665 net_4675 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4665 net_4676 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4665 net_4677 VSS nch_25od w=33u l=0.5u
M_51 net_4676 net_4659 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4677 net_4659 VSS VSS nch_25od w=33u l=0.5u
