************************************************************************************
* TSMC Library/IP Product
* Filename: tpzn65lpgv2od3_3.spi
* Technology: CLN65LP
* Product Type: Standard I/O
* Product Name: tpzn65lpgv2od3
* Version: 200a
*************************************************************************************
**
*  STATEMENT OF USE
*
*  This information contains confidential and proprietary information of TSMC.
*  No part of this information may be reproduced, transmitted, transcribed,
*  stored in a retrieval system, or translated into any human or computer
*  language, in any form or by any means, electronic, mechanical, magnetic,
*  optical, chemical, manual, or otherwise, without the prior written permission
*  of TSMC.  This information was prepared for informational purpose and is for
*  use by TSMC's customers only.  TSMC reserves the right to make changes in the
*  information at any time and without notice.
*
**************************************************************************************
.GLOBAL VDD VSS VDDPST POC
.SUBCKT PCI33DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_2 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_3 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_4 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_5 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_6 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_7 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_8 net_1 net_1 rppolywo w=0.4u l=1.3u m=1
X_9 net_2 net_0 rppolywo w=0.4u l=1.3u m=1
X_10 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_11 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_12 net_0 net_0 rppolywo w=0.4u l=1.3u m=1
X_13 net_1 net_1 rppolywo w=0.4u l=1.3u m=1
X_14 net_1 net_1 rppolywo w=0.4u l=1.3u m=1
X_15 net_1 net_1 rppolywo w=0.4u l=1.3u m=1
X_16 net_1 net_1 rppolywo w=0.4u l=1.3u m=1
X_17 net_3 net_4 rnpolywo w=0.4u l=2.93u m=1
X_18 net_4 net_5 rnpolywo w=0.4u l=2.93u m=1
X_19 net_6 net_6 rnpolywo w=0.4u l=2.93u m=1
X_20 net_7 net_7 rnpolywo w=0.4u l=2.93u m=1
X_21 net_7 net_7 rnpolywo w=0.4u l=2.93u m=1
X_22 net_6 net_6 rnpolywo w=0.4u l=2.93u m=1
X_23 net_5 net_6 rnpolywo w=0.4u l=2.93u m=1
X_24 net_7 net_7 rnpolywo w=0.4u l=2.93u m=1
X_25 net_7 net_7 rnpolywo w=0.4u l=2.93u m=1
X_26 net_6 net_6 rnpolywo w=0.4u l=2.93u m=1
X_27 net_6 net_6 rnpolywo w=0.4u l=2.93u m=1
X_28 net_6 net_6 rnpolywo w=0.4u l=2.93u m=1
M_29 PAD net_8 net_9 VSS nch_25od w=33u l=0.5u
M_30 net_9 net_4 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_8 net_10 VSS nch_25od w=33u l=0.5u
M_32 PAD net_8 net_11 VSS nch_25od w=33u l=0.5u
M_33 PAD net_8 net_12 VSS nch_25od w=33u l=0.5u
M_34 PAD net_8 net_13 VSS nch_25od w=33u l=0.5u
M_35 PAD net_8 net_14 VSS nch_25od w=33u l=0.5u
M_36 net_15 net_6 VSS VSS nch_25od w=33u l=0.5u
M_37 net_16 net_6 VSS VSS nch_25od w=33u l=0.5u
M_38 net_17 net_6 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_8 net_15 VSS nch_25od w=33u l=0.5u
M_40 PAD net_8 net_16 VSS nch_25od w=33u l=0.5u
M_41 PAD net_8 net_17 VSS nch_25od w=33u l=0.5u
M_42 net_14 net_5 VSS VSS nch_25od w=33u l=0.5u
M_43 PAD net_8 net_18 VSS nch_25od w=33u l=0.5u
M_44 PAD net_8 net_19 VSS nch_25od w=33u l=0.5u
M_45 PAD net_8 net_20 VSS nch_25od w=33u l=0.5u
M_46 net_18 net_6 VSS VSS nch_25od w=33u l=0.5u
M_47 net_19 net_6 VSS VSS nch_25od w=33u l=0.5u
M_48 net_20 net_6 VSS VSS nch_25od w=33u l=0.5u
M_49 net_10 net_7 VSS VSS nch_25od w=33u l=0.5u
M_50 net_11 net_7 VSS VSS nch_25od w=33u l=0.5u
M_51 net_12 net_7 VSS VSS nch_25od w=33u l=0.5u
M_52 net_13 net_7 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_54 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_55 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_56 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_57 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_58 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_59 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_60 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_61 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_62 PAD net_1 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_63 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_64 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_65 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_66 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_67 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_68 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_69 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_70 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_71 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_72 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_73 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_74 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_75 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_76 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_77 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_78 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_79 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_80 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_81 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_82 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_83 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_84 PAD net_0 VDDPST net_1 pch_25od w=16.5u l=0.415u
M_85 VSS net_21 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1 net_1 net_1 net_1 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_22 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_23 net_24 VSS VSS nch_25od w=5u l=0.5u
M_90 net_25 net_24 net_23 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_25 net_24 net_26 VDDPST pch_25od w=5u l=0.415u
M_93 net_26 net_27 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_28 net_29 net_3 VDDPST pch_25od w=20u l=0.415u
M_95 net_28 net_30 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_3 net_30 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_29 net_3 VSS nch_25od w=15u l=0.5u
M_98 net_31 net_32 VSS VSS nch_25od w=10u l=0.5u
M_99 net_33 net_34 net_35 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_36 VSS nch_25od w=10u l=0.5u
M_101 net_37 net_34 net_38 VSS nch_25od w=10u l=0.5u
M_102 net_36 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_36 net_31 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_36 net_31 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_38 VSS nch w=10u l=0.09u
M_106 net_33 net_32 VSS VSS nch w=10u l=0.09u
M_107 net_37 I net_36 VSS nch_na25 w=5.5u l=1.32u
M_108 net_31 net_32 net_35 VSS nch_na25 w=5.5u l=1.32u
M_109 net_39 net_40 VSS VSS nch_25od w=10u l=0.5u
M_110 net_41 net_34 net_42 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_43 VSS nch_25od w=10u l=0.5u
M_112 net_44 net_34 net_45 VSS nch_25od w=10u l=0.5u
M_113 net_43 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_43 net_39 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_43 net_39 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_45 VSS nch w=10u l=0.09u
M_117 net_41 net_40 VSS VSS nch w=10u l=0.09u
M_118 net_44 OEN net_43 VSS nch_na25 w=5.5u l=1.32u
M_119 net_39 net_40 net_42 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_46 net_47 VDDPST pch_25od w=40u l=0.415u
M_121 net_47 net_48 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_49 net_46 net_47 VSS nch_25od w=20u l=0.5u
M_123 net_49 net_48 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_50 net_51 VSS nch w=3u l=0.1u
M_125 net_50 net_51 VDD VDD pch w=4u l=0.1u
M_126 net_51 net_50 net_50 VDD pch w=4u l=0.1u
M_127 net_21 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_22 net_52 VSS VSS nch_25od w=20u l=0.5u
M_129 net_21 net_50 VSS VSS nch_25od w=20u l=0.5u
M_130 net_21 net_22 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_22 net_21 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_34 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_34 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_27 PAD rnpolywo w=2u l=3.68u
X_135 net_7 VSS rppolywo w=1.84u l=2.76u
X_136 VDDPST net_53 rppolywo w=3.5u l=0.8u
X_137 VDDPST net_8 rppolywo w=3.5u l=0.8u
D_138 VSS net_50 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_54 net_31 VSS VSS nch_25od w=2u l=0.5u
M_142 net_54 net_31 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_48 net_39 VSS VSS nch_25od w=3u l=0.5u
M_144 net_48 net_39 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_29 net_36 VSS VSS nch_25od w=7u l=0.5u
M_146 net_29 net_36 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_46 net_54 VSS VSS nch_25od w=10u l=0.5u
M_148 net_46 net_54 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_30 net_43 VSS VSS nch_25od w=3u l=0.5u
M_150 net_30 net_43 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_32 I VSS VSS nch w=3u l=0.09u
M_152 net_32 I VDD VDD pch w=7.5u l=0.09u
M_153 net_40 OEN VSS VSS nch w=3u l=0.09u
M_154 net_40 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_52 net_50 VSS VSS nch w=3u l=0.09u
M_156 net_52 net_50 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_55 C VSS nch w=20u l=0.09u
M_158 VSS net_56 net_55 VSS nch w=10u l=0.09u
M_159 VDD net_55 C VDD pch w=30u l=0.09u
M_160 VDD net_56 net_55 VDD pch w=10u l=0.09u
M_161 VSS net_25 net_57 VSS nch_25od w=0.6u l=0.5u
M_162 net_56 net_57 VDD VSS nch_25od w=5u l=0.5u
M_163 net_58 net_48 VSS VSS nch_25od w=10u l=0.5u
M_164 net_59 net_53 net_58 VSS nch_25od w=10u l=0.5u
M_165 net_2 net_53 net_47 VSS nch_25od w=30u l=0.5u
M_166 VSS net_25 net_56 VSS nch_25od w=5u l=0.5u
M_167 net_27 net_53 net_24 VSS nch_25od w=30u l=0.5u
M_168 net_60 net_53 net_59 VSS nch_25od w=10u l=0.5u
M_169 net_24 net_30 net_60 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_25 net_57 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_59 net_53 net_27 net_1 pch_25od w=26u l=0.415u
M_172 net_2 net_59 net_47 net_1 pch_25od w=26u l=0.415u
M_173 VDD net_25 net_56 VDD pch_25od w=5u l=0.415u
M_174 net_1 net_59 VDDPST net_1 pch_25od w=24u l=0.415u
M_175 net_1 net_53 net_27 net_1 pch_25od w=24u l=0.415u
M_176 net_2 net_53 net_27 net_1 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PCI33DGZ
.SUBCKT PCI33SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_2 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_3 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_4 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_5 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_6 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_7 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_8 net_62 net_62 rppolywo w=0.4u l=1.3u m=1
X_9 net_63 net_61 rppolywo w=0.4u l=1.3u m=1
X_10 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_11 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_12 net_61 net_61 rppolywo w=0.4u l=1.3u m=1
X_13 net_62 net_62 rppolywo w=0.4u l=1.3u m=1
X_14 net_62 net_62 rppolywo w=0.4u l=1.3u m=1
X_15 net_62 net_62 rppolywo w=0.4u l=1.3u m=1
X_16 net_62 net_62 rppolywo w=0.4u l=1.3u m=1
X_17 net_64 net_65 rnpolywo w=0.4u l=2.93u m=1
X_18 net_65 net_66 rnpolywo w=0.4u l=2.93u m=1
X_19 net_67 net_67 rnpolywo w=0.4u l=2.93u m=1
X_20 net_68 net_68 rnpolywo w=0.4u l=2.93u m=1
X_21 net_68 net_68 rnpolywo w=0.4u l=2.93u m=1
X_22 net_67 net_67 rnpolywo w=0.4u l=2.93u m=1
X_23 net_66 net_67 rnpolywo w=0.4u l=2.93u m=1
X_24 net_68 net_68 rnpolywo w=0.4u l=2.93u m=1
X_25 net_68 net_68 rnpolywo w=0.4u l=2.93u m=1
X_26 net_67 net_67 rnpolywo w=0.4u l=2.93u m=1
X_27 net_67 net_67 rnpolywo w=0.4u l=2.93u m=1
X_28 net_67 net_67 rnpolywo w=0.4u l=2.93u m=1
M_29 PAD net_69 net_70 VSS nch_25od w=33u l=0.5u
M_30 net_70 net_65 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_69 net_71 VSS nch_25od w=33u l=0.5u
M_32 PAD net_69 net_72 VSS nch_25od w=33u l=0.5u
M_33 PAD net_69 net_73 VSS nch_25od w=33u l=0.5u
M_34 PAD net_69 net_74 VSS nch_25od w=33u l=0.5u
M_35 PAD net_69 net_75 VSS nch_25od w=33u l=0.5u
M_36 net_76 net_67 VSS VSS nch_25od w=33u l=0.5u
M_37 net_77 net_67 VSS VSS nch_25od w=33u l=0.5u
M_38 net_78 net_67 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_69 net_76 VSS nch_25od w=33u l=0.5u
M_40 PAD net_69 net_77 VSS nch_25od w=33u l=0.5u
M_41 PAD net_69 net_78 VSS nch_25od w=33u l=0.5u
M_42 net_75 net_66 VSS VSS nch_25od w=33u l=0.5u
M_43 PAD net_69 net_79 VSS nch_25od w=33u l=0.5u
M_44 PAD net_69 net_80 VSS nch_25od w=33u l=0.5u
M_45 PAD net_69 net_81 VSS nch_25od w=33u l=0.5u
M_46 net_79 net_67 VSS VSS nch_25od w=33u l=0.5u
M_47 net_80 net_67 VSS VSS nch_25od w=33u l=0.5u
M_48 net_81 net_67 VSS VSS nch_25od w=33u l=0.5u
M_49 net_71 net_68 VSS VSS nch_25od w=33u l=0.5u
M_50 net_72 net_68 VSS VSS nch_25od w=33u l=0.5u
M_51 net_73 net_68 VSS VSS nch_25od w=33u l=0.5u
M_52 net_74 net_68 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_54 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_55 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_56 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_57 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_58 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_59 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_60 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_61 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_62 PAD net_62 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_63 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_64 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_65 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_66 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_67 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_68 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_69 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_70 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_71 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_72 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_73 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_74 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_75 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_76 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_77 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_78 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_79 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_80 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_81 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_82 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_83 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_84 PAD net_61 VDDPST net_62 pch_25od w=16.5u l=0.415u
M_85 VSS net_82 VSS VSS nch_25od w=0.5u l=3u
M_86 net_62 net_62 net_62 net_62 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_83 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_84 net_85 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_84 net_86 VSS VSS nch_25od w=5u l=0.5u
M_90 net_85 net_86 net_84 VSS nch_25od w=5u l=0.5u
M_91 net_87 net_85 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_85 net_86 net_87 VDDPST pch_25od w=5u l=0.415u
M_93 net_87 net_88 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_89 net_90 net_64 VDDPST pch_25od w=20u l=0.415u
M_95 net_89 net_91 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_64 net_91 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_90 net_64 VSS nch_25od w=15u l=0.5u
M_98 net_92 net_93 VSS VSS nch_25od w=10u l=0.5u
M_99 net_94 net_95 net_96 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_97 VSS nch_25od w=10u l=0.5u
M_101 net_98 net_95 net_99 VSS nch_25od w=10u l=0.5u
M_102 net_97 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_97 net_92 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_97 net_92 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_99 VSS nch w=10u l=0.09u
M_106 net_94 net_93 VSS VSS nch w=10u l=0.09u
M_107 net_98 I net_97 VSS nch_na25 w=5.5u l=1.32u
M_108 net_92 net_93 net_96 VSS nch_na25 w=5.5u l=1.32u
M_109 net_100 net_101 VSS VSS nch_25od w=10u l=0.5u
M_110 net_102 net_95 net_103 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_104 VSS nch_25od w=10u l=0.5u
M_112 net_105 net_95 net_106 VSS nch_25od w=10u l=0.5u
M_113 net_104 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_104 net_100 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_104 net_100 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_106 VSS nch w=10u l=0.09u
M_117 net_102 net_101 VSS VSS nch w=10u l=0.09u
M_118 net_105 OEN net_104 VSS nch_na25 w=5.5u l=1.32u
M_119 net_100 net_101 net_103 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_107 net_108 VDDPST pch_25od w=40u l=0.415u
M_121 net_108 net_109 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_110 net_107 net_108 VSS nch_25od w=20u l=0.5u
M_123 net_110 net_109 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_111 net_112 VSS nch w=3u l=0.1u
M_125 net_111 net_112 VDD VDD pch w=4u l=0.1u
M_126 net_112 net_111 net_111 VDD pch w=4u l=0.1u
M_127 net_82 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_83 net_113 VSS VSS nch_25od w=20u l=0.5u
M_129 net_82 net_111 VSS VSS nch_25od w=20u l=0.5u
M_130 net_82 net_83 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_83 net_82 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_95 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_95 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_88 PAD rnpolywo w=2u l=3.68u
X_135 net_68 VSS rppolywo w=1.84u l=2.76u
X_136 VDDPST net_114 rppolywo w=3.5u l=0.8u
X_137 VDDPST net_69 rppolywo w=3.5u l=0.8u
D_138 VSS net_111 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_115 net_92 VSS VSS nch_25od w=2u l=0.5u
M_142 net_115 net_92 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_109 net_100 VSS VSS nch_25od w=3u l=0.5u
M_144 net_109 net_100 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_90 net_97 VSS VSS nch_25od w=7u l=0.5u
M_146 net_90 net_97 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_107 net_115 VSS VSS nch_25od w=10u l=0.5u
M_148 net_107 net_115 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_91 net_104 VSS VSS nch_25od w=3u l=0.5u
M_150 net_91 net_104 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_93 I VSS VSS nch w=3u l=0.09u
M_152 net_93 I VDD VDD pch w=7.5u l=0.09u
M_153 net_101 OEN VSS VSS nch w=3u l=0.09u
M_154 net_101 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_113 net_111 VSS VSS nch w=3u l=0.09u
M_156 net_113 net_111 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_116 C VSS nch w=20u l=0.09u
M_158 VSS net_117 net_116 VSS nch w=10u l=0.09u
M_159 VDD net_116 C VDD pch w=30u l=0.09u
M_160 VDD net_117 net_116 VDD pch w=10u l=0.09u
M_161 VSS net_85 net_118 VSS nch_25od w=0.6u l=0.5u
M_162 net_117 net_118 VDD VSS nch_25od w=5u l=0.5u
M_163 net_119 net_109 VSS VSS nch_25od w=10u l=0.5u
M_164 net_120 net_114 net_119 VSS nch_25od w=10u l=0.5u
M_165 net_63 net_114 net_108 VSS nch_25od w=30u l=0.5u
M_166 VSS net_85 net_117 VSS nch_25od w=5u l=0.5u
M_167 net_88 net_114 net_86 VSS nch_25od w=30u l=0.5u
M_168 net_121 net_114 net_120 VSS nch_25od w=10u l=0.5u
M_169 net_86 net_91 net_121 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_85 net_118 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_120 net_114 net_88 net_62 pch_25od w=26u l=0.415u
M_172 net_63 net_120 net_108 net_62 pch_25od w=26u l=0.415u
M_173 VDD net_85 net_117 VDD pch_25od w=5u l=0.415u
M_174 net_62 net_120 VDDPST net_62 pch_25od w=24u l=0.415u
M_175 net_62 net_114 net_88 net_62 pch_25od w=24u l=0.415u
M_176 net_63 net_114 net_88 net_62 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PCI33SDGZ
.SUBCKT PCI66DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_2 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_3 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_4 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_5 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_6 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_7 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_8 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_9 net_122 net_122 rppolywo w=0.4u l=1.3u m=1
X_10 net_124 net_122 rppolywo w=0.4u l=0.43u m=1
X_11 net_122 net_123 rppolywo w=0.4u l=1.3u m=1
X_12 net_123 net_123 rppolywo w=0.4u l=0.43u m=1
X_13 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_14 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_15 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_16 net_123 net_123 rppolywo w=0.4u l=1.3u m=1
X_17 net_125 net_125 rnpolywo w=0.4u l=2.93u m=1
X_18 net_126 net_127 rnpolywo w=0.59u l=2.93u m=1
X_19 net_128 net_128 rnpolywo w=0.4u l=2.93u m=1
X_20 net_127 net_129 rnpolywo w=0.4u l=2.93u m=1
X_21 net_125 net_125 rnpolywo w=0.4u l=2.93u m=1
X_22 net_125 net_125 rnpolywo w=0.4u l=2.93u m=1
X_23 net_129 net_128 rnpolywo w=0.4u l=2.93u m=1
X_24 net_128 net_128 rnpolywo w=0.4u l=2.93u m=1
X_25 net_128 net_128 rnpolywo w=0.4u l=2.93u m=1
X_26 net_125 net_125 rnpolywo w=0.4u l=2.93u m=1
X_27 net_128 net_128 rnpolywo w=0.4u l=2.93u m=1
X_28 net_128 net_128 rnpolywo w=0.4u l=2.93u m=1
M_29 PAD net_130 net_131 VSS nch_25od w=33u l=0.5u
M_30 net_131 net_127 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_130 net_132 VSS nch_25od w=33u l=0.5u
M_32 net_133 net_128 VSS VSS nch_25od w=33u l=0.5u
M_33 net_134 net_128 VSS VSS nch_25od w=33u l=0.5u
M_34 net_135 net_128 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_130 net_133 VSS nch_25od w=33u l=0.5u
M_36 PAD net_130 net_134 VSS nch_25od w=33u l=0.5u
M_37 PAD net_130 net_135 VSS nch_25od w=33u l=0.5u
M_38 net_132 net_129 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_130 net_136 VSS nch_25od w=33u l=0.5u
M_40 PAD net_130 net_137 VSS nch_25od w=33u l=0.5u
M_41 PAD net_130 net_138 VSS nch_25od w=33u l=0.5u
M_42 PAD net_130 net_139 VSS nch_25od w=33u l=0.5u
M_43 PAD net_130 net_140 VSS nch_25od w=33u l=0.5u
M_44 net_139 net_128 VSS VSS nch_25od w=33u l=0.5u
M_45 net_140 net_128 VSS VSS nch_25od w=33u l=0.5u
M_46 PAD net_130 net_141 VSS nch_25od w=33u l=0.5u
M_47 PAD net_130 net_142 VSS nch_25od w=33u l=0.5u
M_48 net_136 net_125 VSS VSS nch_25od w=33u l=0.5u
M_49 net_137 net_125 VSS VSS nch_25od w=33u l=0.5u
M_50 net_138 net_125 VSS VSS nch_25od w=33u l=0.5u
M_51 net_141 net_128 VSS VSS nch_25od w=33u l=0.5u
M_52 net_142 net_128 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_54 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_55 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_56 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_57 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_58 PAD net_123 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_59 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_60 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_61 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_62 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_63 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_64 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_65 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_66 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_67 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_68 PAD net_143 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_69 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_70 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_71 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_72 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_73 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_74 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_75 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_76 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_77 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_78 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_79 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_80 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_81 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_82 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_83 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_84 PAD net_122 VDDPST net_143 pch_25od w=16.5u l=0.415u
M_85 VSS net_144 VSS VSS nch_25od w=0.5u l=3u
M_86 net_143 net_143 net_143 net_143 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_145 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_146 net_147 VSS VSS nch_25od w=5u l=0.5u
M_90 net_148 net_147 net_146 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_148 net_147 net_149 VDDPST pch_25od w=5u l=0.415u
M_93 net_149 net_150 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_151 net_152 net_126 VDDPST pch_25od w=20u l=0.415u
M_95 net_151 net_153 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_126 net_153 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_152 net_126 VSS nch_25od w=15u l=0.5u
M_98 net_154 net_155 VSS VSS nch_25od w=10u l=0.5u
M_99 net_156 net_157 net_158 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_159 VSS nch_25od w=10u l=0.5u
M_101 net_160 net_157 net_161 VSS nch_25od w=10u l=0.5u
M_102 net_159 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_159 net_154 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_159 net_154 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_161 VSS nch w=10u l=0.09u
M_106 net_156 net_155 VSS VSS nch w=10u l=0.09u
M_107 net_160 I net_159 VSS nch_na25 w=5.5u l=1.32u
M_108 net_154 net_155 net_158 VSS nch_na25 w=5.5u l=1.32u
M_109 net_162 net_163 VSS VSS nch_25od w=10u l=0.5u
M_110 net_164 net_157 net_165 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_166 VSS nch_25od w=10u l=0.5u
M_112 net_167 net_157 net_168 VSS nch_25od w=10u l=0.5u
M_113 net_166 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_166 net_162 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_166 net_162 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_168 VSS nch w=10u l=0.09u
M_117 net_164 net_163 VSS VSS nch w=10u l=0.09u
M_118 net_167 OEN net_166 VSS nch_na25 w=5.5u l=1.32u
M_119 net_162 net_163 net_165 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_169 net_170 VDDPST pch_25od w=40u l=0.415u
M_121 net_170 net_171 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_172 net_169 net_170 VSS nch_25od w=20u l=0.5u
M_123 net_172 net_171 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_173 net_174 VSS nch w=3u l=0.1u
M_125 net_173 net_174 VDD VDD pch w=4u l=0.1u
M_126 net_174 net_173 net_173 VDD pch w=4u l=0.1u
M_127 net_144 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_145 net_175 VSS VSS nch_25od w=20u l=0.5u
M_129 net_144 net_173 VSS VSS nch_25od w=20u l=0.5u
M_130 net_144 net_145 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_145 net_144 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_157 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_157 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_150 PAD rnpolywo w=2u l=3.68u
X_135 net_125 VSS rppolywo w=1.84u l=2.76u
X_136 VDDPST net_176 rppolywo w=3.5u l=0.8u
X_137 VDDPST net_130 rppolywo w=3.5u l=0.8u
D_138 VSS net_173 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_177 net_154 VSS VSS nch_25od w=2u l=0.5u
M_142 net_177 net_154 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_171 net_162 VSS VSS nch_25od w=3u l=0.5u
M_144 net_171 net_162 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_152 net_159 VSS VSS nch_25od w=7u l=0.5u
M_146 net_152 net_159 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_169 net_177 VSS VSS nch_25od w=10u l=0.5u
M_148 net_169 net_177 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_153 net_166 VSS VSS nch_25od w=3u l=0.5u
M_150 net_153 net_166 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_155 I VSS VSS nch w=3u l=0.09u
M_152 net_155 I VDD VDD pch w=7.5u l=0.09u
M_153 net_163 OEN VSS VSS nch w=3u l=0.09u
M_154 net_163 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_175 net_173 VSS VSS nch w=3u l=0.09u
M_156 net_175 net_173 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_178 C VSS nch w=20u l=0.09u
M_158 VSS net_179 net_178 VSS nch w=10u l=0.09u
M_159 VDD net_178 C VDD pch w=30u l=0.09u
M_160 VDD net_179 net_178 VDD pch w=10u l=0.09u
M_161 VSS net_148 net_180 VSS nch_25od w=0.6u l=0.5u
M_162 net_179 net_180 VDD VSS nch_25od w=5u l=0.5u
M_163 net_181 net_171 VSS VSS nch_25od w=10u l=0.5u
M_164 net_182 net_176 net_181 VSS nch_25od w=10u l=0.5u
M_165 net_124 net_176 net_170 VSS nch_25od w=30u l=0.5u
M_166 VSS net_148 net_179 VSS nch_25od w=5u l=0.5u
M_167 net_150 net_176 net_147 VSS nch_25od w=30u l=0.5u
M_168 net_183 net_176 net_182 VSS nch_25od w=10u l=0.5u
M_169 net_147 net_153 net_183 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_148 net_180 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_182 net_176 net_150 net_143 pch_25od w=26u l=0.415u
M_172 net_124 net_182 net_170 net_143 pch_25od w=26u l=0.415u
M_173 VDD net_148 net_179 VDD pch_25od w=5u l=0.415u
M_174 net_143 net_182 VDDPST net_143 pch_25od w=24u l=0.415u
M_175 net_143 net_176 net_150 net_143 pch_25od w=24u l=0.415u
M_176 net_124 net_176 net_150 net_143 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PCI66DGZ
.SUBCKT PCI66SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_2 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_3 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_4 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_5 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_6 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_7 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_8 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_9 net_184 net_184 rppolywo w=0.4u l=1.3u m=1
X_10 net_186 net_184 rppolywo w=0.4u l=0.43u m=1
X_11 net_184 net_185 rppolywo w=0.4u l=1.3u m=1
X_12 net_185 net_185 rppolywo w=0.4u l=0.43u m=1
X_13 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_14 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_15 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_16 net_185 net_185 rppolywo w=0.4u l=1.3u m=1
X_17 net_187 net_187 rnpolywo w=0.4u l=2.93u m=1
X_18 net_188 net_189 rnpolywo w=0.59u l=2.93u m=1
X_19 net_190 net_190 rnpolywo w=0.4u l=2.93u m=1
X_20 net_189 net_191 rnpolywo w=0.4u l=2.93u m=1
X_21 net_187 net_187 rnpolywo w=0.4u l=2.93u m=1
X_22 net_187 net_187 rnpolywo w=0.4u l=2.93u m=1
X_23 net_191 net_190 rnpolywo w=0.4u l=2.93u m=1
X_24 net_190 net_190 rnpolywo w=0.4u l=2.93u m=1
X_25 net_190 net_190 rnpolywo w=0.4u l=2.93u m=1
X_26 net_187 net_187 rnpolywo w=0.4u l=2.93u m=1
X_27 net_190 net_190 rnpolywo w=0.4u l=2.93u m=1
X_28 net_190 net_190 rnpolywo w=0.4u l=2.93u m=1
M_29 PAD net_192 net_193 VSS nch_25od w=33u l=0.5u
M_30 net_193 net_189 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_192 net_194 VSS nch_25od w=33u l=0.5u
M_32 net_195 net_190 VSS VSS nch_25od w=33u l=0.5u
M_33 net_196 net_190 VSS VSS nch_25od w=33u l=0.5u
M_34 net_197 net_190 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_192 net_195 VSS nch_25od w=33u l=0.5u
M_36 PAD net_192 net_196 VSS nch_25od w=33u l=0.5u
M_37 PAD net_192 net_197 VSS nch_25od w=33u l=0.5u
M_38 net_194 net_191 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_192 net_198 VSS nch_25od w=33u l=0.5u
M_40 PAD net_192 net_199 VSS nch_25od w=33u l=0.5u
M_41 PAD net_192 net_200 VSS nch_25od w=33u l=0.5u
M_42 PAD net_192 net_201 VSS nch_25od w=33u l=0.5u
M_43 PAD net_192 net_202 VSS nch_25od w=33u l=0.5u
M_44 net_201 net_190 VSS VSS nch_25od w=33u l=0.5u
M_45 net_202 net_190 VSS VSS nch_25od w=33u l=0.5u
M_46 PAD net_192 net_203 VSS nch_25od w=33u l=0.5u
M_47 PAD net_192 net_204 VSS nch_25od w=33u l=0.5u
M_48 net_198 net_187 VSS VSS nch_25od w=33u l=0.5u
M_49 net_199 net_187 VSS VSS nch_25od w=33u l=0.5u
M_50 net_200 net_187 VSS VSS nch_25od w=33u l=0.5u
M_51 net_203 net_190 VSS VSS nch_25od w=33u l=0.5u
M_52 net_204 net_190 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_54 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_55 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_56 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_57 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_58 PAD net_185 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_59 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_60 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_61 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_62 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_63 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_64 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_65 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_66 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_67 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_68 PAD net_205 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_69 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_70 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_71 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_72 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_73 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_74 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_75 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_76 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_77 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_78 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_79 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_80 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_81 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_82 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_83 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_84 PAD net_184 VDDPST net_205 pch_25od w=16.5u l=0.415u
M_85 VSS net_206 VSS VSS nch_25od w=0.5u l=3u
M_86 net_205 net_205 net_205 net_205 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_207 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_208 net_209 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_208 net_210 VSS VSS nch_25od w=5u l=0.5u
M_90 net_209 net_210 net_208 VSS nch_25od w=5u l=0.5u
M_91 net_211 net_209 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_209 net_210 net_211 VDDPST pch_25od w=5u l=0.415u
M_93 net_211 net_212 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_213 net_214 net_188 VDDPST pch_25od w=20u l=0.415u
M_95 net_213 net_215 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_188 net_215 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_214 net_188 VSS nch_25od w=15u l=0.5u
M_98 net_216 net_217 VSS VSS nch_25od w=10u l=0.5u
M_99 net_218 net_219 net_220 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_221 VSS nch_25od w=10u l=0.5u
M_101 net_222 net_219 net_223 VSS nch_25od w=10u l=0.5u
M_102 net_221 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_221 net_216 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_221 net_216 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_223 VSS nch w=10u l=0.09u
M_106 net_218 net_217 VSS VSS nch w=10u l=0.09u
M_107 net_222 I net_221 VSS nch_na25 w=5.5u l=1.32u
M_108 net_216 net_217 net_220 VSS nch_na25 w=5.5u l=1.32u
M_109 net_224 net_225 VSS VSS nch_25od w=10u l=0.5u
M_110 net_226 net_219 net_227 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_228 VSS nch_25od w=10u l=0.5u
M_112 net_229 net_219 net_230 VSS nch_25od w=10u l=0.5u
M_113 net_228 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_228 net_224 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_228 net_224 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_230 VSS nch w=10u l=0.09u
M_117 net_226 net_225 VSS VSS nch w=10u l=0.09u
M_118 net_229 OEN net_228 VSS nch_na25 w=5.5u l=1.32u
M_119 net_224 net_225 net_227 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_231 net_232 VDDPST pch_25od w=40u l=0.415u
M_121 net_232 net_233 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_234 net_231 net_232 VSS nch_25od w=20u l=0.5u
M_123 net_234 net_233 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_235 net_236 VSS nch w=3u l=0.1u
M_125 net_235 net_236 VDD VDD pch w=4u l=0.1u
M_126 net_236 net_235 net_235 VDD pch w=4u l=0.1u
M_127 net_206 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_207 net_237 VSS VSS nch_25od w=20u l=0.5u
M_129 net_206 net_235 VSS VSS nch_25od w=20u l=0.5u
M_130 net_206 net_207 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_207 net_206 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_219 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_219 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_212 PAD rnpolywo w=2u l=3.68u
X_135 net_187 VSS rppolywo w=1.84u l=2.76u
X_136 VDDPST net_238 rppolywo w=3.5u l=0.8u
X_137 VDDPST net_192 rppolywo w=3.5u l=0.8u
D_138 VSS net_235 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_239 net_216 VSS VSS nch_25od w=2u l=0.5u
M_142 net_239 net_216 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_233 net_224 VSS VSS nch_25od w=3u l=0.5u
M_144 net_233 net_224 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_214 net_221 VSS VSS nch_25od w=7u l=0.5u
M_146 net_214 net_221 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_231 net_239 VSS VSS nch_25od w=10u l=0.5u
M_148 net_231 net_239 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_215 net_228 VSS VSS nch_25od w=3u l=0.5u
M_150 net_215 net_228 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_217 I VSS VSS nch w=3u l=0.09u
M_152 net_217 I VDD VDD pch w=7.5u l=0.09u
M_153 net_225 OEN VSS VSS nch w=3u l=0.09u
M_154 net_225 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_237 net_235 VSS VSS nch w=3u l=0.09u
M_156 net_237 net_235 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_240 C VSS nch w=20u l=0.09u
M_158 VSS net_241 net_240 VSS nch w=10u l=0.09u
M_159 VDD net_240 C VDD pch w=30u l=0.09u
M_160 VDD net_241 net_240 VDD pch w=10u l=0.09u
M_161 VSS net_209 net_242 VSS nch_25od w=0.6u l=0.5u
M_162 net_241 net_242 VDD VSS nch_25od w=5u l=0.5u
M_163 net_243 net_233 VSS VSS nch_25od w=10u l=0.5u
M_164 net_244 net_238 net_243 VSS nch_25od w=10u l=0.5u
M_165 net_186 net_238 net_232 VSS nch_25od w=30u l=0.5u
M_166 VSS net_209 net_241 VSS nch_25od w=5u l=0.5u
M_167 net_212 net_238 net_210 VSS nch_25od w=30u l=0.5u
M_168 net_245 net_238 net_244 VSS nch_25od w=10u l=0.5u
M_169 net_210 net_215 net_245 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_209 net_242 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_244 net_238 net_212 net_205 pch_25od w=26u l=0.415u
M_172 net_186 net_244 net_232 net_205 pch_25od w=26u l=0.415u
M_173 VDD net_209 net_241 VDD pch_25od w=5u l=0.415u
M_174 net_205 net_244 VDDPST net_205 pch_25od w=24u l=0.415u
M_175 net_205 net_238 net_212 net_205 pch_25od w=24u l=0.415u
M_176 net_186 net_238 net_212 net_205 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PCI66SDGZ
.SUBCKT PCLAMP1ANA VDDESD VSSESD
M_0 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_1 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_2 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_3 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_4 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_5 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_6 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_7 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_8 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_9 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_10 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_11 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_12 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_13 VSSESD net_7007 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_14 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_15 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_16 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_17 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_18 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_19 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_20 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_21 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_22 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_23 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_24 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_25 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_26 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_27 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_28 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_29 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_30 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_31 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_32 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_33 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_34 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_35 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_36 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_37 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_38 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_39 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_40 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_41 net_7008 net_7007 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_42 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_43 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_44 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_45 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_46 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_47 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_48 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_49 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_50 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_51 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_52 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_53 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_54 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_55 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_56 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_57 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_58 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_59 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_60 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_61 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_62 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_63 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_64 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_65 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_66 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_67 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_68 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_69 net_7008 net_7007 VDDESD VDDESD pch_25od w=3u l=0.415u
M_70 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_71 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_72 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_73 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_74 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_75 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_76 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_77 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_78 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_79 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_80 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_81 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_82 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_83 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_84 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_85 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_86 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_87 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_88 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_89 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_90 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_91 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_92 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_93 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_94 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_95 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_96 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_97 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_98 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_99 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_100 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_101 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_102 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_103 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_104 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_105 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_106 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_107 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_108 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_109 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_110 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_111 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_112 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_113 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_114 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_115 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_116 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_117 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_118 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_119 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_120 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_121 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_122 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_123 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_124 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
M_125 VDDESD net_7008 VSSESD VSSESD nch_hvt w=41u l=0.13u
X_126 VDDESD net_7007 rppolywo w=0.5u l=1846.76u m=1
*PGATE NGATE
.ENDS PCLAMP1ANA
.SUBCKT PCLAMP2ANA VDDESD VSSESD
M_0 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_1 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_2 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_3 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_4 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_5 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_6 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_7 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_8 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_9 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_10 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_11 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_12 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_13 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_14 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_15 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_16 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_17 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_18 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_19 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_20 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_21 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_22 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_23 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_24 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_25 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_26 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_27 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_28 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_29 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_30 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_31 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_32 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_33 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_34 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_35 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_36 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_37 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_38 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_39 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_40 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_41 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_42 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_43 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_44 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_45 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_46 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_47 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_48 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_49 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_50 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_51 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_52 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_53 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_54 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_55 VDDESD net_7009 VSSESD VSSESD nch_25od w=41u l=0.5u
M_56 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_57 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_58 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_59 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_60 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_61 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_62 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_63 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_64 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_65 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_66 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_67 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_68 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_69 VSSESD net_7010 VSSESD VSSESD nch_25od w=8.3u l=3.7u
M_70 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_71 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_72 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_73 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_74 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_75 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_76 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_77 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_78 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_79 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_80 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_81 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_82 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_83 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_84 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_85 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_86 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_87 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_88 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_89 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_90 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_91 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_92 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_93 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_94 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_95 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_96 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_97 net_7009 net_7010 VSSESD VSSESD nch_25od w=1.5u l=0.5u
M_98 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_99 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_100 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_101 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_102 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_103 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_104 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_105 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_106 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_107 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_108 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_109 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_110 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_111 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_112 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_113 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_114 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_115 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_116 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_117 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_118 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_119 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_120 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_121 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_122 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_123 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_124 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
M_125 net_7009 net_7010 VDDESD VDDESD pch_25od w=3u l=0.415u
X_126 VDDESD net_7010 rppolywo w=0.5u l=1846.76u m=1
*PGATE NGATE
.ENDS PCLAMP2ANA
.SUBCKT PDB02DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_2 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_3 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_4 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_5 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_6 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_7 net_247 net_247 rnpolywo w=0.4u l=2.93u m=1
X_8 net_247 net_247 rnpolywo w=0.4u l=2.93u m=1
X_9 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_10 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_11 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_12 net_246 net_246 rnpolywo w=0.4u l=2.93u m=1
X_13 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_14 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_15 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_16 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_17 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_18 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_19 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_20 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_21 net_249 net_249 rppolywo w=0.4u l=1.3u m=1
X_22 net_249 net_249 rppolywo w=0.4u l=1.3u m=1
X_23 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_24 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_25 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_26 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_27 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
X_28 net_248 net_248 rppolywo w=0.4u l=1.3u m=1
M_29 net_250 net_246 VSS VSS nch_25od w=33u l=0.5u
M_30 net_251 net_246 VSS VSS nch_25od w=33u l=0.5u
M_31 net_252 net_246 VSS VSS nch_25od w=33u l=0.5u
M_32 net_253 net_246 VSS VSS nch_25od w=33u l=0.5u
M_33 net_254 net_246 VSS VSS nch_25od w=33u l=0.5u
M_34 net_255 net_246 VSS VSS nch_25od w=33u l=0.5u
M_35 net_256 net_246 VSS VSS nch_25od w=33u l=0.5u
M_36 net_257 net_246 VSS VSS nch_25od w=33u l=0.5u
M_37 net_258 net_246 VSS VSS nch_25od w=33u l=0.5u
M_38 net_259 net_246 VSS VSS nch_25od w=33u l=0.5u
M_39 net_260 net_246 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_261 net_250 VSS nch_25od w=33u l=0.5u
M_41 PAD net_261 net_251 VSS nch_25od w=33u l=0.5u
M_42 PAD net_261 net_252 VSS nch_25od w=33u l=0.5u
M_43 PAD net_261 net_253 VSS nch_25od w=33u l=0.5u
M_44 PAD net_261 net_254 VSS nch_25od w=33u l=0.5u
M_45 PAD net_261 net_255 VSS nch_25od w=33u l=0.5u
M_46 PAD net_261 net_256 VSS nch_25od w=33u l=0.5u
M_47 PAD net_261 net_257 VSS nch_25od w=33u l=0.5u
M_48 PAD net_261 net_258 VSS nch_25od w=33u l=0.5u
M_49 PAD net_261 net_259 VSS nch_25od w=33u l=0.5u
M_50 PAD net_261 net_260 VSS nch_25od w=33u l=0.5u
M_51 PAD net_261 net_262 VSS nch_25od w=33u l=0.5u
M_52 net_262 net_247 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_54 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_55 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_56 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_57 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_58 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_59 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_60 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_61 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_62 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_63 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_64 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_65 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_66 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_67 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_68 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_69 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_70 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_71 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_72 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_73 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_74 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_75 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_76 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_77 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_78 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_79 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_80 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_81 PAD net_248 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_82 PAD net_249 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_83 PAD net_249 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_84 PAD net_249 VDDPST net_248 pch_25od w=16.5u l=0.415u
M_85 VSS net_263 VSS VSS nch_25od w=0.5u l=3u
M_86 net_248 net_248 net_248 net_248 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_264 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_265 net_266 VSS VSS nch_25od w=5u l=0.5u
M_90 net_267 net_266 net_265 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_267 net_266 net_268 VDDPST pch_25od w=5u l=0.415u
M_93 net_268 net_269 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_270 net_271 net_247 VDDPST pch_25od w=20u l=0.415u
M_95 net_270 net_272 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_247 net_272 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_271 net_247 VSS nch_25od w=15u l=0.5u
M_98 net_273 net_274 VSS VSS nch_25od w=10u l=0.5u
M_99 net_275 net_276 net_277 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_278 VSS nch_25od w=10u l=0.5u
M_101 net_279 net_276 net_280 VSS nch_25od w=10u l=0.5u
M_102 net_278 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_278 net_273 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_278 net_273 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_280 VSS nch w=10u l=0.09u
M_106 net_275 net_274 VSS VSS nch w=10u l=0.09u
M_107 net_279 I net_278 VSS nch_na25 w=5.5u l=1.32u
M_108 net_273 net_274 net_277 VSS nch_na25 w=5.5u l=1.32u
M_109 net_281 net_282 VSS VSS nch_25od w=10u l=0.5u
M_110 net_283 net_276 net_284 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_285 VSS nch_25od w=10u l=0.5u
M_112 net_286 net_276 net_287 VSS nch_25od w=10u l=0.5u
M_113 net_285 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_285 net_281 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_285 net_281 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_287 VSS nch w=10u l=0.09u
M_117 net_283 net_282 VSS VSS nch w=10u l=0.09u
M_118 net_286 OEN net_285 VSS nch_na25 w=5.5u l=1.32u
M_119 net_281 net_282 net_284 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_288 net_289 VDDPST pch_25od w=40u l=0.415u
M_121 net_289 net_290 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_291 net_288 net_289 VSS nch_25od w=20u l=0.5u
M_123 net_291 net_290 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_292 net_293 VSS nch w=3u l=0.1u
M_125 net_292 net_293 VDD VDD pch w=4u l=0.1u
M_126 net_293 net_292 net_292 VDD pch w=4u l=0.1u
M_127 net_263 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_264 net_294 VSS VSS nch_25od w=20u l=0.5u
M_129 net_263 net_292 VSS VSS nch_25od w=20u l=0.5u
M_130 net_263 net_264 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_264 net_263 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_276 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_276 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_269 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_246 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_295 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_261 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_292 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_296 net_273 VSS VSS nch_25od w=2u l=0.5u
M_142 net_296 net_273 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_290 net_281 VSS VSS nch_25od w=3u l=0.5u
M_144 net_290 net_281 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_271 net_278 VSS VSS nch_25od w=7u l=0.5u
M_146 net_271 net_278 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_288 net_296 VSS VSS nch_25od w=10u l=0.5u
M_148 net_288 net_296 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_272 net_285 VSS VSS nch_25od w=3u l=0.5u
M_150 net_272 net_285 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_274 I VSS VSS nch w=3u l=0.09u
M_152 net_274 I VDD VDD pch w=7.5u l=0.09u
M_153 net_282 OEN VSS VSS nch w=3u l=0.09u
M_154 net_282 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_294 net_292 VSS VSS nch w=3u l=0.09u
M_156 net_294 net_292 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_297 C VSS nch w=20u l=0.09u
M_158 VSS net_298 net_297 VSS nch w=10u l=0.09u
M_159 VDD net_297 C VDD pch w=30u l=0.09u
M_160 VDD net_298 net_297 VDD pch w=10u l=0.09u
M_161 VSS net_267 net_299 VSS nch_25od w=0.6u l=0.5u
M_162 net_298 net_299 VDD VSS nch_25od w=5u l=0.5u
M_163 net_300 net_290 VSS VSS nch_25od w=10u l=0.5u
M_164 net_301 net_295 net_300 VSS nch_25od w=10u l=0.5u
M_165 net_249 net_295 net_289 VSS nch_25od w=30u l=0.5u
M_166 VSS net_267 net_298 VSS nch_25od w=5u l=0.5u
M_167 net_269 net_295 net_266 VSS nch_25od w=30u l=0.5u
M_168 net_302 net_295 net_301 VSS nch_25od w=10u l=0.5u
M_169 net_266 net_272 net_302 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_267 net_299 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_301 net_295 net_269 net_248 pch_25od w=26u l=0.415u
M_172 net_249 net_301 net_289 net_248 pch_25od w=26u l=0.415u
M_173 VDD net_267 net_298 VDD pch_25od w=5u l=0.415u
M_174 net_248 net_301 VDDPST net_248 pch_25od w=24u l=0.415u
M_175 net_248 net_295 net_269 net_248 pch_25od w=24u l=0.415u
M_176 net_249 net_295 net_269 net_248 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB02DGZ
.SUBCKT PDB02SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_2 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_3 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_4 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_5 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_6 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_7 net_304 net_304 rnpolywo w=0.4u l=2.93u m=1
X_8 net_304 net_304 rnpolywo w=0.4u l=2.93u m=1
X_9 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_10 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_11 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_12 net_303 net_303 rnpolywo w=0.4u l=2.93u m=1
X_13 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_14 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_15 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_16 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_17 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_18 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_19 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_20 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_21 net_306 net_306 rppolywo w=0.4u l=1.3u m=1
X_22 net_306 net_306 rppolywo w=0.4u l=1.3u m=1
X_23 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_24 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_25 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_26 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_27 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
X_28 net_305 net_305 rppolywo w=0.4u l=1.3u m=1
M_29 net_307 net_303 VSS VSS nch_25od w=33u l=0.5u
M_30 net_308 net_303 VSS VSS nch_25od w=33u l=0.5u
M_31 net_309 net_303 VSS VSS nch_25od w=33u l=0.5u
M_32 net_310 net_303 VSS VSS nch_25od w=33u l=0.5u
M_33 net_311 net_303 VSS VSS nch_25od w=33u l=0.5u
M_34 net_312 net_303 VSS VSS nch_25od w=33u l=0.5u
M_35 net_313 net_303 VSS VSS nch_25od w=33u l=0.5u
M_36 net_314 net_303 VSS VSS nch_25od w=33u l=0.5u
M_37 net_315 net_303 VSS VSS nch_25od w=33u l=0.5u
M_38 net_316 net_303 VSS VSS nch_25od w=33u l=0.5u
M_39 net_317 net_303 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_318 net_307 VSS nch_25od w=33u l=0.5u
M_41 PAD net_318 net_308 VSS nch_25od w=33u l=0.5u
M_42 PAD net_318 net_309 VSS nch_25od w=33u l=0.5u
M_43 PAD net_318 net_310 VSS nch_25od w=33u l=0.5u
M_44 PAD net_318 net_311 VSS nch_25od w=33u l=0.5u
M_45 PAD net_318 net_312 VSS nch_25od w=33u l=0.5u
M_46 PAD net_318 net_313 VSS nch_25od w=33u l=0.5u
M_47 PAD net_318 net_314 VSS nch_25od w=33u l=0.5u
M_48 PAD net_318 net_315 VSS nch_25od w=33u l=0.5u
M_49 PAD net_318 net_316 VSS nch_25od w=33u l=0.5u
M_50 PAD net_318 net_317 VSS nch_25od w=33u l=0.5u
M_51 PAD net_318 net_319 VSS nch_25od w=33u l=0.5u
M_52 net_319 net_304 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_54 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_55 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_56 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_57 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_58 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_59 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_60 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_61 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_62 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_63 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_64 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_65 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_66 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_67 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_68 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_69 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_70 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_71 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_72 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_73 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_74 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_75 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_76 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_77 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_78 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_79 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_80 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_81 PAD net_305 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_82 PAD net_306 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_83 PAD net_306 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_84 PAD net_306 VDDPST net_305 pch_25od w=16.5u l=0.415u
M_85 VSS net_320 VSS VSS nch_25od w=0.5u l=3u
M_86 net_305 net_305 net_305 net_305 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_321 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_322 net_323 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_322 net_324 VSS VSS nch_25od w=5u l=0.5u
M_90 net_323 net_324 net_322 VSS nch_25od w=5u l=0.5u
M_91 net_325 net_323 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_323 net_324 net_325 VDDPST pch_25od w=5u l=0.415u
M_93 net_325 net_326 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_327 net_328 net_304 VDDPST pch_25od w=20u l=0.415u
M_95 net_327 net_329 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_304 net_329 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_328 net_304 VSS nch_25od w=15u l=0.5u
M_98 net_330 net_331 VSS VSS nch_25od w=10u l=0.5u
M_99 net_332 net_333 net_334 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_335 VSS nch_25od w=10u l=0.5u
M_101 net_336 net_333 net_337 VSS nch_25od w=10u l=0.5u
M_102 net_335 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_335 net_330 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_335 net_330 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_337 VSS nch w=10u l=0.09u
M_106 net_332 net_331 VSS VSS nch w=10u l=0.09u
M_107 net_336 I net_335 VSS nch_na25 w=5.5u l=1.32u
M_108 net_330 net_331 net_334 VSS nch_na25 w=5.5u l=1.32u
M_109 net_338 net_339 VSS VSS nch_25od w=10u l=0.5u
M_110 net_340 net_333 net_341 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_342 VSS nch_25od w=10u l=0.5u
M_112 net_343 net_333 net_344 VSS nch_25od w=10u l=0.5u
M_113 net_342 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_342 net_338 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_342 net_338 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_344 VSS nch w=10u l=0.09u
M_117 net_340 net_339 VSS VSS nch w=10u l=0.09u
M_118 net_343 OEN net_342 VSS nch_na25 w=5.5u l=1.32u
M_119 net_338 net_339 net_341 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_345 net_346 VDDPST pch_25od w=40u l=0.415u
M_121 net_346 net_347 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_348 net_345 net_346 VSS nch_25od w=20u l=0.5u
M_123 net_348 net_347 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_349 net_350 VSS nch w=3u l=0.1u
M_125 net_349 net_350 VDD VDD pch w=4u l=0.1u
M_126 net_350 net_349 net_349 VDD pch w=4u l=0.1u
M_127 net_320 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_321 net_351 VSS VSS nch_25od w=20u l=0.5u
M_129 net_320 net_349 VSS VSS nch_25od w=20u l=0.5u
M_130 net_320 net_321 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_321 net_320 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_333 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_333 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_326 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_303 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_352 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_318 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_349 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_353 net_330 VSS VSS nch_25od w=2u l=0.5u
M_142 net_353 net_330 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_347 net_338 VSS VSS nch_25od w=3u l=0.5u
M_144 net_347 net_338 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_328 net_335 VSS VSS nch_25od w=7u l=0.5u
M_146 net_328 net_335 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_345 net_353 VSS VSS nch_25od w=10u l=0.5u
M_148 net_345 net_353 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_329 net_342 VSS VSS nch_25od w=3u l=0.5u
M_150 net_329 net_342 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_331 I VSS VSS nch w=3u l=0.09u
M_152 net_331 I VDD VDD pch w=7.5u l=0.09u
M_153 net_339 OEN VSS VSS nch w=3u l=0.09u
M_154 net_339 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_351 net_349 VSS VSS nch w=3u l=0.09u
M_156 net_351 net_349 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_354 C VSS nch w=20u l=0.09u
M_158 VSS net_355 net_354 VSS nch w=10u l=0.09u
M_159 VDD net_354 C VDD pch w=30u l=0.09u
M_160 VDD net_355 net_354 VDD pch w=10u l=0.09u
M_161 VSS net_323 net_356 VSS nch_25od w=0.6u l=0.5u
M_162 net_355 net_356 VDD VSS nch_25od w=5u l=0.5u
M_163 net_357 net_347 VSS VSS nch_25od w=10u l=0.5u
M_164 net_358 net_352 net_357 VSS nch_25od w=10u l=0.5u
M_165 net_306 net_352 net_346 VSS nch_25od w=30u l=0.5u
M_166 VSS net_323 net_355 VSS nch_25od w=5u l=0.5u
M_167 net_326 net_352 net_324 VSS nch_25od w=30u l=0.5u
M_168 net_359 net_352 net_358 VSS nch_25od w=10u l=0.5u
M_169 net_324 net_329 net_359 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_323 net_356 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_358 net_352 net_326 net_305 pch_25od w=26u l=0.415u
M_172 net_306 net_358 net_346 net_305 pch_25od w=26u l=0.415u
M_173 VDD net_323 net_355 VDD pch_25od w=5u l=0.415u
M_174 net_305 net_358 VDDPST net_305 pch_25od w=24u l=0.415u
M_175 net_305 net_352 net_326 net_305 pch_25od w=24u l=0.415u
M_176 net_306 net_352 net_326 net_305 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB02SDGZ
.SUBCKT PDB04DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_2 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_3 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_4 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_5 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_6 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_7 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_8 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_9 net_361 net_361 rnpolywo w=0.4u l=2.93u m=1
X_10 net_361 net_361 rnpolywo w=0.4u l=2.93u m=1
X_11 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_12 net_360 net_360 rnpolywo w=0.4u l=2.93u m=1
X_13 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_14 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_15 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_16 net_363 net_363 rppolywo w=0.4u l=1.3u m=1
X_17 net_363 net_363 rppolywo w=0.4u l=1.3u m=1
X_18 net_363 net_363 rppolywo w=0.4u l=1.3u m=1
X_19 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_20 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_21 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_22 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_23 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_24 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_25 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_26 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_27 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
X_28 net_362 net_362 rppolywo w=0.4u l=1.3u m=1
M_29 net_364 net_360 VSS VSS nch_25od w=33u l=0.5u
M_30 net_365 net_360 VSS VSS nch_25od w=33u l=0.5u
M_31 net_366 net_360 VSS VSS nch_25od w=33u l=0.5u
M_32 net_367 net_360 VSS VSS nch_25od w=33u l=0.5u
M_33 net_368 net_360 VSS VSS nch_25od w=33u l=0.5u
M_34 net_369 net_360 VSS VSS nch_25od w=33u l=0.5u
M_35 net_370 net_360 VSS VSS nch_25od w=33u l=0.5u
M_36 net_371 net_360 VSS VSS nch_25od w=33u l=0.5u
M_37 net_372 net_360 VSS VSS nch_25od w=33u l=0.5u
M_38 net_373 net_360 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_374 net_364 VSS nch_25od w=33u l=0.5u
M_40 PAD net_374 net_365 VSS nch_25od w=33u l=0.5u
M_41 PAD net_374 net_366 VSS nch_25od w=33u l=0.5u
M_42 PAD net_374 net_367 VSS nch_25od w=33u l=0.5u
M_43 PAD net_374 net_368 VSS nch_25od w=33u l=0.5u
M_44 PAD net_374 net_369 VSS nch_25od w=33u l=0.5u
M_45 PAD net_374 net_370 VSS nch_25od w=33u l=0.5u
M_46 PAD net_374 net_371 VSS nch_25od w=33u l=0.5u
M_47 PAD net_374 net_372 VSS nch_25od w=33u l=0.5u
M_48 PAD net_374 net_373 VSS nch_25od w=33u l=0.5u
M_49 PAD net_374 net_375 VSS nch_25od w=33u l=0.5u
M_50 PAD net_374 net_376 VSS nch_25od w=33u l=0.5u
M_51 net_375 net_361 VSS VSS nch_25od w=33u l=0.5u
M_52 net_376 net_361 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_54 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_55 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_56 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_57 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_58 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_59 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_60 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_61 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_62 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_63 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_64 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_65 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_66 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_67 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_68 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_69 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_70 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_71 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_72 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_73 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_74 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_75 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_76 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_77 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_78 PAD net_362 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_79 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_80 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_81 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_82 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_83 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_84 PAD net_363 VDDPST net_362 pch_25od w=16.5u l=0.415u
M_85 VSS net_377 VSS VSS nch_25od w=0.5u l=3u
M_86 net_362 net_362 net_362 net_362 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_378 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_379 net_380 VSS VSS nch_25od w=5u l=0.5u
M_90 net_381 net_380 net_379 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_381 net_380 net_382 VDDPST pch_25od w=5u l=0.415u
M_93 net_382 net_383 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_384 net_385 net_361 VDDPST pch_25od w=20u l=0.415u
M_95 net_384 net_386 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_361 net_386 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_385 net_361 VSS nch_25od w=15u l=0.5u
M_98 net_387 net_388 VSS VSS nch_25od w=10u l=0.5u
M_99 net_389 net_390 net_391 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_392 VSS nch_25od w=10u l=0.5u
M_101 net_393 net_390 net_394 VSS nch_25od w=10u l=0.5u
M_102 net_392 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_392 net_387 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_392 net_387 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_394 VSS nch w=10u l=0.09u
M_106 net_389 net_388 VSS VSS nch w=10u l=0.09u
M_107 net_393 I net_392 VSS nch_na25 w=5.5u l=1.32u
M_108 net_387 net_388 net_391 VSS nch_na25 w=5.5u l=1.32u
M_109 net_395 net_396 VSS VSS nch_25od w=10u l=0.5u
M_110 net_397 net_390 net_398 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_399 VSS nch_25od w=10u l=0.5u
M_112 net_400 net_390 net_401 VSS nch_25od w=10u l=0.5u
M_113 net_399 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_399 net_395 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_399 net_395 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_401 VSS nch w=10u l=0.09u
M_117 net_397 net_396 VSS VSS nch w=10u l=0.09u
M_118 net_400 OEN net_399 VSS nch_na25 w=5.5u l=1.32u
M_119 net_395 net_396 net_398 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_402 net_403 VDDPST pch_25od w=40u l=0.415u
M_121 net_403 net_404 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_405 net_402 net_403 VSS nch_25od w=20u l=0.5u
M_123 net_405 net_404 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_406 net_407 VSS nch w=3u l=0.1u
M_125 net_406 net_407 VDD VDD pch w=4u l=0.1u
M_126 net_407 net_406 net_406 VDD pch w=4u l=0.1u
M_127 net_377 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_378 net_408 VSS VSS nch_25od w=20u l=0.5u
M_129 net_377 net_406 VSS VSS nch_25od w=20u l=0.5u
M_130 net_377 net_378 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_378 net_377 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_390 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_390 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_383 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_360 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_409 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_374 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_406 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_410 net_387 VSS VSS nch_25od w=2u l=0.5u
M_142 net_410 net_387 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_404 net_395 VSS VSS nch_25od w=3u l=0.5u
M_144 net_404 net_395 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_385 net_392 VSS VSS nch_25od w=7u l=0.5u
M_146 net_385 net_392 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_402 net_410 VSS VSS nch_25od w=10u l=0.5u
M_148 net_402 net_410 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_386 net_399 VSS VSS nch_25od w=3u l=0.5u
M_150 net_386 net_399 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_388 I VSS VSS nch w=3u l=0.09u
M_152 net_388 I VDD VDD pch w=7.5u l=0.09u
M_153 net_396 OEN VSS VSS nch w=3u l=0.09u
M_154 net_396 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_408 net_406 VSS VSS nch w=3u l=0.09u
M_156 net_408 net_406 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_411 C VSS nch w=20u l=0.09u
M_158 VSS net_412 net_411 VSS nch w=10u l=0.09u
M_159 VDD net_411 C VDD pch w=30u l=0.09u
M_160 VDD net_412 net_411 VDD pch w=10u l=0.09u
M_161 VSS net_381 net_413 VSS nch_25od w=0.6u l=0.5u
M_162 net_412 net_413 VDD VSS nch_25od w=5u l=0.5u
M_163 net_414 net_404 VSS VSS nch_25od w=10u l=0.5u
M_164 net_415 net_409 net_414 VSS nch_25od w=10u l=0.5u
M_165 net_363 net_409 net_403 VSS nch_25od w=30u l=0.5u
M_166 VSS net_381 net_412 VSS nch_25od w=5u l=0.5u
M_167 net_383 net_409 net_380 VSS nch_25od w=30u l=0.5u
M_168 net_416 net_409 net_415 VSS nch_25od w=10u l=0.5u
M_169 net_380 net_386 net_416 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_381 net_413 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_415 net_409 net_383 net_362 pch_25od w=26u l=0.415u
M_172 net_363 net_415 net_403 net_362 pch_25od w=26u l=0.415u
M_173 VDD net_381 net_412 VDD pch_25od w=5u l=0.415u
M_174 net_362 net_415 VDDPST net_362 pch_25od w=24u l=0.415u
M_175 net_362 net_409 net_383 net_362 pch_25od w=24u l=0.415u
M_176 net_363 net_409 net_383 net_362 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB04DGZ
.SUBCKT PDB04SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_2 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_3 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_4 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_5 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_6 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_7 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_8 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_9 net_418 net_418 rnpolywo w=0.4u l=2.93u m=1
X_10 net_418 net_418 rnpolywo w=0.4u l=2.93u m=1
X_11 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_12 net_417 net_417 rnpolywo w=0.4u l=2.93u m=1
X_13 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_14 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_15 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_16 net_420 net_420 rppolywo w=0.4u l=1.3u m=1
X_17 net_420 net_420 rppolywo w=0.4u l=1.3u m=1
X_18 net_420 net_420 rppolywo w=0.4u l=1.3u m=1
X_19 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_20 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_21 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_22 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_23 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_24 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_25 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_26 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_27 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
X_28 net_419 net_419 rppolywo w=0.4u l=1.3u m=1
M_29 net_421 net_417 VSS VSS nch_25od w=33u l=0.5u
M_30 net_422 net_417 VSS VSS nch_25od w=33u l=0.5u
M_31 net_423 net_417 VSS VSS nch_25od w=33u l=0.5u
M_32 net_424 net_417 VSS VSS nch_25od w=33u l=0.5u
M_33 net_425 net_417 VSS VSS nch_25od w=33u l=0.5u
M_34 net_426 net_417 VSS VSS nch_25od w=33u l=0.5u
M_35 net_427 net_417 VSS VSS nch_25od w=33u l=0.5u
M_36 net_428 net_417 VSS VSS nch_25od w=33u l=0.5u
M_37 net_429 net_417 VSS VSS nch_25od w=33u l=0.5u
M_38 net_430 net_417 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_431 net_421 VSS nch_25od w=33u l=0.5u
M_40 PAD net_431 net_422 VSS nch_25od w=33u l=0.5u
M_41 PAD net_431 net_423 VSS nch_25od w=33u l=0.5u
M_42 PAD net_431 net_424 VSS nch_25od w=33u l=0.5u
M_43 PAD net_431 net_425 VSS nch_25od w=33u l=0.5u
M_44 PAD net_431 net_426 VSS nch_25od w=33u l=0.5u
M_45 PAD net_431 net_427 VSS nch_25od w=33u l=0.5u
M_46 PAD net_431 net_428 VSS nch_25od w=33u l=0.5u
M_47 PAD net_431 net_429 VSS nch_25od w=33u l=0.5u
M_48 PAD net_431 net_430 VSS nch_25od w=33u l=0.5u
M_49 PAD net_431 net_432 VSS nch_25od w=33u l=0.5u
M_50 PAD net_431 net_433 VSS nch_25od w=33u l=0.5u
M_51 net_432 net_418 VSS VSS nch_25od w=33u l=0.5u
M_52 net_433 net_418 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_54 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_55 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_56 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_57 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_58 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_59 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_60 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_61 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_62 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_63 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_64 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_65 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_66 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_67 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_68 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_69 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_70 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_71 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_72 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_73 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_74 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_75 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_76 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_77 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_78 PAD net_419 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_79 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_80 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_81 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_82 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_83 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_84 PAD net_420 VDDPST net_419 pch_25od w=16.5u l=0.415u
M_85 VSS net_434 VSS VSS nch_25od w=0.5u l=3u
M_86 net_419 net_419 net_419 net_419 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_435 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_436 net_437 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_436 net_438 VSS VSS nch_25od w=5u l=0.5u
M_90 net_437 net_438 net_436 VSS nch_25od w=5u l=0.5u
M_91 net_439 net_437 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_437 net_438 net_439 VDDPST pch_25od w=5u l=0.415u
M_93 net_439 net_440 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_441 net_442 net_418 VDDPST pch_25od w=20u l=0.415u
M_95 net_441 net_443 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_418 net_443 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_442 net_418 VSS nch_25od w=15u l=0.5u
M_98 net_444 net_445 VSS VSS nch_25od w=10u l=0.5u
M_99 net_446 net_447 net_448 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_449 VSS nch_25od w=10u l=0.5u
M_101 net_450 net_447 net_451 VSS nch_25od w=10u l=0.5u
M_102 net_449 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_449 net_444 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_449 net_444 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_451 VSS nch w=10u l=0.09u
M_106 net_446 net_445 VSS VSS nch w=10u l=0.09u
M_107 net_450 I net_449 VSS nch_na25 w=5.5u l=1.32u
M_108 net_444 net_445 net_448 VSS nch_na25 w=5.5u l=1.32u
M_109 net_452 net_453 VSS VSS nch_25od w=10u l=0.5u
M_110 net_454 net_447 net_455 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_456 VSS nch_25od w=10u l=0.5u
M_112 net_457 net_447 net_458 VSS nch_25od w=10u l=0.5u
M_113 net_456 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_456 net_452 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_456 net_452 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_458 VSS nch w=10u l=0.09u
M_117 net_454 net_453 VSS VSS nch w=10u l=0.09u
M_118 net_457 OEN net_456 VSS nch_na25 w=5.5u l=1.32u
M_119 net_452 net_453 net_455 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_459 net_460 VDDPST pch_25od w=40u l=0.415u
M_121 net_460 net_461 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_462 net_459 net_460 VSS nch_25od w=20u l=0.5u
M_123 net_462 net_461 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_463 net_464 VSS nch w=3u l=0.1u
M_125 net_463 net_464 VDD VDD pch w=4u l=0.1u
M_126 net_464 net_463 net_463 VDD pch w=4u l=0.1u
M_127 net_434 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_435 net_465 VSS VSS nch_25od w=20u l=0.5u
M_129 net_434 net_463 VSS VSS nch_25od w=20u l=0.5u
M_130 net_434 net_435 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_435 net_434 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_447 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_447 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_440 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_417 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_466 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_431 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_463 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_467 net_444 VSS VSS nch_25od w=2u l=0.5u
M_142 net_467 net_444 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_461 net_452 VSS VSS nch_25od w=3u l=0.5u
M_144 net_461 net_452 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_442 net_449 VSS VSS nch_25od w=7u l=0.5u
M_146 net_442 net_449 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_459 net_467 VSS VSS nch_25od w=10u l=0.5u
M_148 net_459 net_467 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_443 net_456 VSS VSS nch_25od w=3u l=0.5u
M_150 net_443 net_456 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_445 I VSS VSS nch w=3u l=0.09u
M_152 net_445 I VDD VDD pch w=7.5u l=0.09u
M_153 net_453 OEN VSS VSS nch w=3u l=0.09u
M_154 net_453 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_465 net_463 VSS VSS nch w=3u l=0.09u
M_156 net_465 net_463 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_468 C VSS nch w=20u l=0.09u
M_158 VSS net_469 net_468 VSS nch w=10u l=0.09u
M_159 VDD net_468 C VDD pch w=30u l=0.09u
M_160 VDD net_469 net_468 VDD pch w=10u l=0.09u
M_161 VSS net_437 net_470 VSS nch_25od w=0.6u l=0.5u
M_162 net_469 net_470 VDD VSS nch_25od w=5u l=0.5u
M_163 net_471 net_461 VSS VSS nch_25od w=10u l=0.5u
M_164 net_472 net_466 net_471 VSS nch_25od w=10u l=0.5u
M_165 net_420 net_466 net_460 VSS nch_25od w=30u l=0.5u
M_166 VSS net_437 net_469 VSS nch_25od w=5u l=0.5u
M_167 net_440 net_466 net_438 VSS nch_25od w=30u l=0.5u
M_168 net_473 net_466 net_472 VSS nch_25od w=10u l=0.5u
M_169 net_438 net_443 net_473 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_437 net_470 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_472 net_466 net_440 net_419 pch_25od w=26u l=0.415u
M_172 net_420 net_472 net_460 net_419 pch_25od w=26u l=0.415u
M_173 VDD net_437 net_469 VDD pch_25od w=5u l=0.415u
M_174 net_419 net_472 VDDPST net_419 pch_25od w=24u l=0.415u
M_175 net_419 net_466 net_440 net_419 pch_25od w=24u l=0.415u
M_176 net_420 net_466 net_440 net_419 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB04SDGZ
.SUBCKT PDB08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_2 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_3 net_475 net_475 rnpolywo w=0.4u l=2.93u m=1
X_4 net_475 net_475 rnpolywo w=0.4u l=2.93u m=1
X_5 net_475 net_475 rnpolywo w=0.4u l=2.93u m=1
X_6 net_475 net_475 rnpolywo w=0.4u l=2.93u m=1
X_7 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_8 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_9 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_10 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_11 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_12 net_474 net_474 rnpolywo w=0.4u l=2.93u m=1
X_13 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_14 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_15 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_16 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_17 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_18 net_476 net_476 rppolywo w=0.4u l=1.3u m=1
X_19 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_20 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_21 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_22 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_23 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_24 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_25 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_26 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_27 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
X_28 net_477 net_477 rppolywo w=0.4u l=1.3u m=1
M_29 net_478 net_474 VSS VSS nch_25od w=33u l=0.5u
M_30 net_479 net_474 VSS VSS nch_25od w=33u l=0.5u
M_31 net_480 net_474 VSS VSS nch_25od w=33u l=0.5u
M_32 net_481 net_474 VSS VSS nch_25od w=33u l=0.5u
M_33 net_482 net_474 VSS VSS nch_25od w=33u l=0.5u
M_34 net_483 net_474 VSS VSS nch_25od w=33u l=0.5u
M_35 net_484 net_474 VSS VSS nch_25od w=33u l=0.5u
M_36 net_485 net_474 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_486 net_478 VSS nch_25od w=33u l=0.5u
M_38 PAD net_486 net_479 VSS nch_25od w=33u l=0.5u
M_39 PAD net_486 net_480 VSS nch_25od w=33u l=0.5u
M_40 PAD net_486 net_481 VSS nch_25od w=33u l=0.5u
M_41 PAD net_486 net_482 VSS nch_25od w=33u l=0.5u
M_42 PAD net_486 net_483 VSS nch_25od w=33u l=0.5u
M_43 PAD net_486 net_484 VSS nch_25od w=33u l=0.5u
M_44 PAD net_486 net_485 VSS nch_25od w=33u l=0.5u
M_45 PAD net_486 net_487 VSS nch_25od w=33u l=0.5u
M_46 PAD net_486 net_488 VSS nch_25od w=33u l=0.5u
M_47 PAD net_486 net_489 VSS nch_25od w=33u l=0.5u
M_48 PAD net_486 net_490 VSS nch_25od w=33u l=0.5u
M_49 net_487 net_475 VSS VSS nch_25od w=33u l=0.5u
M_50 net_488 net_475 VSS VSS nch_25od w=33u l=0.5u
M_51 net_489 net_475 VSS VSS nch_25od w=33u l=0.5u
M_52 net_490 net_475 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_54 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_55 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_56 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_57 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_58 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_59 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_60 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_61 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_62 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_63 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_64 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_65 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_66 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_67 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_68 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_69 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_70 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_71 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_72 PAD net_477 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_73 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_74 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_75 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_76 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_77 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_78 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_79 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_80 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_81 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_82 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_83 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_84 PAD net_476 VDDPST net_477 pch_25od w=16.5u l=0.415u
M_85 VSS net_491 VSS VSS nch_25od w=0.5u l=3u
M_86 net_477 net_477 net_477 net_477 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_492 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_493 net_494 VSS VSS nch_25od w=5u l=0.5u
M_90 net_495 net_494 net_493 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_495 net_494 net_496 VDDPST pch_25od w=5u l=0.415u
M_93 net_496 net_497 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_498 net_499 net_475 VDDPST pch_25od w=20u l=0.415u
M_95 net_498 net_500 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_475 net_500 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_499 net_475 VSS nch_25od w=15u l=0.5u
M_98 net_501 net_502 VSS VSS nch_25od w=10u l=0.5u
M_99 net_503 net_504 net_505 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_506 VSS nch_25od w=10u l=0.5u
M_101 net_507 net_504 net_508 VSS nch_25od w=10u l=0.5u
M_102 net_506 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_506 net_501 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_506 net_501 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_508 VSS nch w=10u l=0.09u
M_106 net_503 net_502 VSS VSS nch w=10u l=0.09u
M_107 net_507 I net_506 VSS nch_na25 w=5.5u l=1.32u
M_108 net_501 net_502 net_505 VSS nch_na25 w=5.5u l=1.32u
M_109 net_509 net_510 VSS VSS nch_25od w=10u l=0.5u
M_110 net_511 net_504 net_512 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_513 VSS nch_25od w=10u l=0.5u
M_112 net_514 net_504 net_515 VSS nch_25od w=10u l=0.5u
M_113 net_513 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_513 net_509 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_513 net_509 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_515 VSS nch w=10u l=0.09u
M_117 net_511 net_510 VSS VSS nch w=10u l=0.09u
M_118 net_514 OEN net_513 VSS nch_na25 w=5.5u l=1.32u
M_119 net_509 net_510 net_512 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_516 net_517 VDDPST pch_25od w=40u l=0.415u
M_121 net_517 net_518 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_519 net_516 net_517 VSS nch_25od w=20u l=0.5u
M_123 net_519 net_518 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_520 net_521 VSS nch w=3u l=0.1u
M_125 net_520 net_521 VDD VDD pch w=4u l=0.1u
M_126 net_521 net_520 net_520 VDD pch w=4u l=0.1u
M_127 net_491 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_492 net_522 VSS VSS nch_25od w=20u l=0.5u
M_129 net_491 net_520 VSS VSS nch_25od w=20u l=0.5u
M_130 net_491 net_492 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_492 net_491 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_504 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_504 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_497 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_474 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_523 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_486 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_520 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_524 net_501 VSS VSS nch_25od w=2u l=0.5u
M_142 net_524 net_501 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_518 net_509 VSS VSS nch_25od w=3u l=0.5u
M_144 net_518 net_509 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_499 net_506 VSS VSS nch_25od w=7u l=0.5u
M_146 net_499 net_506 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_516 net_524 VSS VSS nch_25od w=10u l=0.5u
M_148 net_516 net_524 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_500 net_513 VSS VSS nch_25od w=3u l=0.5u
M_150 net_500 net_513 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_502 I VSS VSS nch w=3u l=0.09u
M_152 net_502 I VDD VDD pch w=7.5u l=0.09u
M_153 net_510 OEN VSS VSS nch w=3u l=0.09u
M_154 net_510 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_522 net_520 VSS VSS nch w=3u l=0.09u
M_156 net_522 net_520 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_525 C VSS nch w=20u l=0.09u
M_158 VSS net_526 net_525 VSS nch w=10u l=0.09u
M_159 VDD net_525 C VDD pch w=30u l=0.09u
M_160 VDD net_526 net_525 VDD pch w=10u l=0.09u
M_161 VSS net_495 net_527 VSS nch_25od w=0.6u l=0.5u
M_162 net_526 net_527 VDD VSS nch_25od w=5u l=0.5u
M_163 net_528 net_518 VSS VSS nch_25od w=10u l=0.5u
M_164 net_529 net_523 net_528 VSS nch_25od w=10u l=0.5u
M_165 net_476 net_523 net_517 VSS nch_25od w=30u l=0.5u
M_166 VSS net_495 net_526 VSS nch_25od w=5u l=0.5u
M_167 net_497 net_523 net_494 VSS nch_25od w=30u l=0.5u
M_168 net_530 net_523 net_529 VSS nch_25od w=10u l=0.5u
M_169 net_494 net_500 net_530 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_495 net_527 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_529 net_523 net_497 net_477 pch_25od w=26u l=0.415u
M_172 net_476 net_529 net_517 net_477 pch_25od w=26u l=0.415u
M_173 VDD net_495 net_526 VDD pch_25od w=5u l=0.415u
M_174 net_477 net_529 VDDPST net_477 pch_25od w=24u l=0.415u
M_175 net_477 net_523 net_497 net_477 pch_25od w=24u l=0.415u
M_176 net_476 net_523 net_497 net_477 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB08DGZ
.SUBCKT PDB08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_2 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_3 net_532 net_532 rnpolywo w=0.4u l=2.93u m=1
X_4 net_532 net_532 rnpolywo w=0.4u l=2.93u m=1
X_5 net_532 net_532 rnpolywo w=0.4u l=2.93u m=1
X_6 net_532 net_532 rnpolywo w=0.4u l=2.93u m=1
X_7 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_8 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_9 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_10 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_11 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_12 net_531 net_531 rnpolywo w=0.4u l=2.93u m=1
X_13 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_14 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_15 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_16 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_17 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_18 net_533 net_533 rppolywo w=0.4u l=1.3u m=1
X_19 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_20 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_21 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_22 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_23 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_24 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_25 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_26 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_27 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
X_28 net_534 net_534 rppolywo w=0.4u l=1.3u m=1
M_29 net_535 net_531 VSS VSS nch_25od w=33u l=0.5u
M_30 net_536 net_531 VSS VSS nch_25od w=33u l=0.5u
M_31 net_537 net_531 VSS VSS nch_25od w=33u l=0.5u
M_32 net_538 net_531 VSS VSS nch_25od w=33u l=0.5u
M_33 net_539 net_531 VSS VSS nch_25od w=33u l=0.5u
M_34 net_540 net_531 VSS VSS nch_25od w=33u l=0.5u
M_35 net_541 net_531 VSS VSS nch_25od w=33u l=0.5u
M_36 net_542 net_531 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_543 net_535 VSS nch_25od w=33u l=0.5u
M_38 PAD net_543 net_536 VSS nch_25od w=33u l=0.5u
M_39 PAD net_543 net_537 VSS nch_25od w=33u l=0.5u
M_40 PAD net_543 net_538 VSS nch_25od w=33u l=0.5u
M_41 PAD net_543 net_539 VSS nch_25od w=33u l=0.5u
M_42 PAD net_543 net_540 VSS nch_25od w=33u l=0.5u
M_43 PAD net_543 net_541 VSS nch_25od w=33u l=0.5u
M_44 PAD net_543 net_542 VSS nch_25od w=33u l=0.5u
M_45 PAD net_543 net_544 VSS nch_25od w=33u l=0.5u
M_46 PAD net_543 net_545 VSS nch_25od w=33u l=0.5u
M_47 PAD net_543 net_546 VSS nch_25od w=33u l=0.5u
M_48 PAD net_543 net_547 VSS nch_25od w=33u l=0.5u
M_49 net_544 net_532 VSS VSS nch_25od w=33u l=0.5u
M_50 net_545 net_532 VSS VSS nch_25od w=33u l=0.5u
M_51 net_546 net_532 VSS VSS nch_25od w=33u l=0.5u
M_52 net_547 net_532 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_54 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_55 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_56 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_57 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_58 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_59 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_60 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_61 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_62 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_63 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_64 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_65 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_66 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_67 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_68 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_69 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_70 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_71 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_72 PAD net_534 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_73 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_74 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_75 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_76 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_77 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_78 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_79 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_80 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_81 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_82 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_83 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_84 PAD net_533 VDDPST net_534 pch_25od w=16.5u l=0.415u
M_85 VSS net_548 VSS VSS nch_25od w=0.5u l=3u
M_86 net_534 net_534 net_534 net_534 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_549 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_550 net_551 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_550 net_552 VSS VSS nch_25od w=5u l=0.5u
M_90 net_551 net_552 net_550 VSS nch_25od w=5u l=0.5u
M_91 net_553 net_551 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_551 net_552 net_553 VDDPST pch_25od w=5u l=0.415u
M_93 net_553 net_554 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_555 net_556 net_532 VDDPST pch_25od w=20u l=0.415u
M_95 net_555 net_557 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_532 net_557 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_556 net_532 VSS nch_25od w=15u l=0.5u
M_98 net_558 net_559 VSS VSS nch_25od w=10u l=0.5u
M_99 net_560 net_561 net_562 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_563 VSS nch_25od w=10u l=0.5u
M_101 net_564 net_561 net_565 VSS nch_25od w=10u l=0.5u
M_102 net_563 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_563 net_558 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_563 net_558 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_565 VSS nch w=10u l=0.09u
M_106 net_560 net_559 VSS VSS nch w=10u l=0.09u
M_107 net_564 I net_563 VSS nch_na25 w=5.5u l=1.32u
M_108 net_558 net_559 net_562 VSS nch_na25 w=5.5u l=1.32u
M_109 net_566 net_567 VSS VSS nch_25od w=10u l=0.5u
M_110 net_568 net_561 net_569 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_570 VSS nch_25od w=10u l=0.5u
M_112 net_571 net_561 net_572 VSS nch_25od w=10u l=0.5u
M_113 net_570 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_570 net_566 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_570 net_566 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_572 VSS nch w=10u l=0.09u
M_117 net_568 net_567 VSS VSS nch w=10u l=0.09u
M_118 net_571 OEN net_570 VSS nch_na25 w=5.5u l=1.32u
M_119 net_566 net_567 net_569 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_573 net_574 VDDPST pch_25od w=40u l=0.415u
M_121 net_574 net_575 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_576 net_573 net_574 VSS nch_25od w=20u l=0.5u
M_123 net_576 net_575 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_577 net_578 VSS nch w=3u l=0.1u
M_125 net_577 net_578 VDD VDD pch w=4u l=0.1u
M_126 net_578 net_577 net_577 VDD pch w=4u l=0.1u
M_127 net_548 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_549 net_579 VSS VSS nch_25od w=20u l=0.5u
M_129 net_548 net_577 VSS VSS nch_25od w=20u l=0.5u
M_130 net_548 net_549 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_549 net_548 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_561 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_561 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_554 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_531 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_580 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_543 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_577 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_581 net_558 VSS VSS nch_25od w=2u l=0.5u
M_142 net_581 net_558 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_575 net_566 VSS VSS nch_25od w=3u l=0.5u
M_144 net_575 net_566 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_556 net_563 VSS VSS nch_25od w=7u l=0.5u
M_146 net_556 net_563 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_573 net_581 VSS VSS nch_25od w=10u l=0.5u
M_148 net_573 net_581 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_557 net_570 VSS VSS nch_25od w=3u l=0.5u
M_150 net_557 net_570 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_559 I VSS VSS nch w=3u l=0.09u
M_152 net_559 I VDD VDD pch w=7.5u l=0.09u
M_153 net_567 OEN VSS VSS nch w=3u l=0.09u
M_154 net_567 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_579 net_577 VSS VSS nch w=3u l=0.09u
M_156 net_579 net_577 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_582 C VSS nch w=20u l=0.09u
M_158 VSS net_583 net_582 VSS nch w=10u l=0.09u
M_159 VDD net_582 C VDD pch w=30u l=0.09u
M_160 VDD net_583 net_582 VDD pch w=10u l=0.09u
M_161 VSS net_551 net_584 VSS nch_25od w=0.6u l=0.5u
M_162 net_583 net_584 VDD VSS nch_25od w=5u l=0.5u
M_163 net_585 net_575 VSS VSS nch_25od w=10u l=0.5u
M_164 net_586 net_580 net_585 VSS nch_25od w=10u l=0.5u
M_165 net_533 net_580 net_574 VSS nch_25od w=30u l=0.5u
M_166 VSS net_551 net_583 VSS nch_25od w=5u l=0.5u
M_167 net_554 net_580 net_552 VSS nch_25od w=30u l=0.5u
M_168 net_587 net_580 net_586 VSS nch_25od w=10u l=0.5u
M_169 net_552 net_557 net_587 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_551 net_584 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_586 net_580 net_554 net_534 pch_25od w=26u l=0.415u
M_172 net_533 net_586 net_574 net_534 pch_25od w=26u l=0.415u
M_173 VDD net_551 net_583 VDD pch_25od w=5u l=0.415u
M_174 net_534 net_586 VDDPST net_534 pch_25od w=24u l=0.415u
M_175 net_534 net_580 net_554 net_534 pch_25od w=24u l=0.415u
M_176 net_533 net_580 net_554 net_534 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB08SDGZ
.SUBCKT PDB12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_2 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_3 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_4 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_5 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_6 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_7 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_8 net_588 net_588 rnpolywo w=0.4u l=2.93u m=1
X_9 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_10 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_11 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_12 net_589 net_589 rnpolywo w=0.4u l=2.93u m=1
X_13 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_14 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_15 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_16 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_17 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_18 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_19 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_20 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_21 net_590 net_590 rppolywo w=0.4u l=1.3u m=1
X_22 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_23 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_24 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_25 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_26 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_27 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
X_28 net_591 net_591 rppolywo w=0.4u l=1.3u m=1
M_29 net_592 net_589 VSS VSS nch_25od w=33u l=0.5u
M_30 net_593 net_589 VSS VSS nch_25od w=33u l=0.5u
M_31 net_594 net_589 VSS VSS nch_25od w=33u l=0.5u
M_32 net_595 net_589 VSS VSS nch_25od w=33u l=0.5u
M_33 net_596 net_589 VSS VSS nch_25od w=33u l=0.5u
M_34 net_597 net_589 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_598 net_592 VSS nch_25od w=33u l=0.5u
M_36 PAD net_598 net_593 VSS nch_25od w=33u l=0.5u
M_37 PAD net_598 net_594 VSS nch_25od w=33u l=0.5u
M_38 PAD net_598 net_595 VSS nch_25od w=33u l=0.5u
M_39 PAD net_598 net_596 VSS nch_25od w=33u l=0.5u
M_40 PAD net_598 net_597 VSS nch_25od w=33u l=0.5u
M_41 PAD net_598 net_599 VSS nch_25od w=33u l=0.5u
M_42 PAD net_598 net_600 VSS nch_25od w=33u l=0.5u
M_43 PAD net_598 net_601 VSS nch_25od w=33u l=0.5u
M_44 PAD net_598 net_602 VSS nch_25od w=33u l=0.5u
M_45 PAD net_598 net_603 VSS nch_25od w=33u l=0.5u
M_46 PAD net_598 net_604 VSS nch_25od w=33u l=0.5u
M_47 net_599 net_588 VSS VSS nch_25od w=33u l=0.5u
M_48 net_600 net_588 VSS VSS nch_25od w=33u l=0.5u
M_49 net_601 net_588 VSS VSS nch_25od w=33u l=0.5u
M_50 net_602 net_588 VSS VSS nch_25od w=33u l=0.5u
M_51 net_603 net_588 VSS VSS nch_25od w=33u l=0.5u
M_52 net_604 net_588 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_54 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_55 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_56 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_57 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_58 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_59 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_60 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_61 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_62 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_63 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_64 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_65 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_66 PAD net_591 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_67 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_68 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_69 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_70 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_71 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_72 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_73 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_74 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_75 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_76 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_77 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_78 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_79 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_80 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_81 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_82 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_83 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_84 PAD net_590 VDDPST net_591 pch_25od w=16.5u l=0.415u
M_85 VSS net_605 VSS VSS nch_25od w=0.5u l=3u
M_86 net_591 net_591 net_591 net_591 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_606 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_607 net_608 VSS VSS nch_25od w=5u l=0.5u
M_90 net_609 net_608 net_607 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_609 net_608 net_610 VDDPST pch_25od w=5u l=0.415u
M_93 net_610 net_611 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_612 net_613 net_588 VDDPST pch_25od w=20u l=0.415u
M_95 net_612 net_614 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_588 net_614 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_613 net_588 VSS nch_25od w=15u l=0.5u
M_98 net_615 net_616 VSS VSS nch_25od w=10u l=0.5u
M_99 net_617 net_618 net_619 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_620 VSS nch_25od w=10u l=0.5u
M_101 net_621 net_618 net_622 VSS nch_25od w=10u l=0.5u
M_102 net_620 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_620 net_615 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_620 net_615 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_622 VSS nch w=10u l=0.09u
M_106 net_617 net_616 VSS VSS nch w=10u l=0.09u
M_107 net_621 I net_620 VSS nch_na25 w=5.5u l=1.32u
M_108 net_615 net_616 net_619 VSS nch_na25 w=5.5u l=1.32u
M_109 net_623 net_624 VSS VSS nch_25od w=10u l=0.5u
M_110 net_625 net_618 net_626 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_627 VSS nch_25od w=10u l=0.5u
M_112 net_628 net_618 net_629 VSS nch_25od w=10u l=0.5u
M_113 net_627 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_627 net_623 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_627 net_623 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_629 VSS nch w=10u l=0.09u
M_117 net_625 net_624 VSS VSS nch w=10u l=0.09u
M_118 net_628 OEN net_627 VSS nch_na25 w=5.5u l=1.32u
M_119 net_623 net_624 net_626 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_630 net_631 VDDPST pch_25od w=40u l=0.415u
M_121 net_631 net_632 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_633 net_630 net_631 VSS nch_25od w=20u l=0.5u
M_123 net_633 net_632 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_634 net_635 VSS nch w=3u l=0.1u
M_125 net_634 net_635 VDD VDD pch w=4u l=0.1u
M_126 net_635 net_634 net_634 VDD pch w=4u l=0.1u
M_127 net_605 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_606 net_636 VSS VSS nch_25od w=20u l=0.5u
M_129 net_605 net_634 VSS VSS nch_25od w=20u l=0.5u
M_130 net_605 net_606 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_606 net_605 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_618 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_618 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_611 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_589 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_637 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_598 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_634 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_638 net_615 VSS VSS nch_25od w=2u l=0.5u
M_142 net_638 net_615 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_632 net_623 VSS VSS nch_25od w=3u l=0.5u
M_144 net_632 net_623 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_613 net_620 VSS VSS nch_25od w=7u l=0.5u
M_146 net_613 net_620 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_630 net_638 VSS VSS nch_25od w=10u l=0.5u
M_148 net_630 net_638 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_614 net_627 VSS VSS nch_25od w=3u l=0.5u
M_150 net_614 net_627 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_616 I VSS VSS nch w=3u l=0.09u
M_152 net_616 I VDD VDD pch w=7.5u l=0.09u
M_153 net_624 OEN VSS VSS nch w=3u l=0.09u
M_154 net_624 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_636 net_634 VSS VSS nch w=3u l=0.09u
M_156 net_636 net_634 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_639 C VSS nch w=20u l=0.09u
M_158 VSS net_640 net_639 VSS nch w=10u l=0.09u
M_159 VDD net_639 C VDD pch w=30u l=0.09u
M_160 VDD net_640 net_639 VDD pch w=10u l=0.09u
M_161 VSS net_609 net_641 VSS nch_25od w=0.6u l=0.5u
M_162 net_640 net_641 VDD VSS nch_25od w=5u l=0.5u
M_163 net_642 net_632 VSS VSS nch_25od w=10u l=0.5u
M_164 net_643 net_637 net_642 VSS nch_25od w=10u l=0.5u
M_165 net_590 net_637 net_631 VSS nch_25od w=30u l=0.5u
M_166 VSS net_609 net_640 VSS nch_25od w=5u l=0.5u
M_167 net_611 net_637 net_608 VSS nch_25od w=30u l=0.5u
M_168 net_644 net_637 net_643 VSS nch_25od w=10u l=0.5u
M_169 net_608 net_614 net_644 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_609 net_641 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_643 net_637 net_611 net_591 pch_25od w=26u l=0.415u
M_172 net_590 net_643 net_631 net_591 pch_25od w=26u l=0.415u
M_173 VDD net_609 net_640 VDD pch_25od w=5u l=0.415u
M_174 net_591 net_643 VDDPST net_591 pch_25od w=24u l=0.415u
M_175 net_591 net_637 net_611 net_591 pch_25od w=24u l=0.415u
M_176 net_590 net_637 net_611 net_591 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB12DGZ
.SUBCKT PDB12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_2 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_3 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_4 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_5 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_6 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_7 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_8 net_645 net_645 rnpolywo w=0.4u l=2.93u m=1
X_9 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_10 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_11 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_12 net_646 net_646 rnpolywo w=0.4u l=2.93u m=1
X_13 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_14 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_15 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_16 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_17 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_18 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_19 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_20 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_21 net_647 net_647 rppolywo w=0.4u l=1.3u m=1
X_22 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_23 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_24 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_25 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_26 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_27 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
X_28 net_648 net_648 rppolywo w=0.4u l=1.3u m=1
M_29 net_649 net_646 VSS VSS nch_25od w=33u l=0.5u
M_30 net_650 net_646 VSS VSS nch_25od w=33u l=0.5u
M_31 net_651 net_646 VSS VSS nch_25od w=33u l=0.5u
M_32 net_652 net_646 VSS VSS nch_25od w=33u l=0.5u
M_33 net_653 net_646 VSS VSS nch_25od w=33u l=0.5u
M_34 net_654 net_646 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_655 net_649 VSS nch_25od w=33u l=0.5u
M_36 PAD net_655 net_650 VSS nch_25od w=33u l=0.5u
M_37 PAD net_655 net_651 VSS nch_25od w=33u l=0.5u
M_38 PAD net_655 net_652 VSS nch_25od w=33u l=0.5u
M_39 PAD net_655 net_653 VSS nch_25od w=33u l=0.5u
M_40 PAD net_655 net_654 VSS nch_25od w=33u l=0.5u
M_41 PAD net_655 net_656 VSS nch_25od w=33u l=0.5u
M_42 PAD net_655 net_657 VSS nch_25od w=33u l=0.5u
M_43 PAD net_655 net_658 VSS nch_25od w=33u l=0.5u
M_44 PAD net_655 net_659 VSS nch_25od w=33u l=0.5u
M_45 PAD net_655 net_660 VSS nch_25od w=33u l=0.5u
M_46 PAD net_655 net_661 VSS nch_25od w=33u l=0.5u
M_47 net_656 net_645 VSS VSS nch_25od w=33u l=0.5u
M_48 net_657 net_645 VSS VSS nch_25od w=33u l=0.5u
M_49 net_658 net_645 VSS VSS nch_25od w=33u l=0.5u
M_50 net_659 net_645 VSS VSS nch_25od w=33u l=0.5u
M_51 net_660 net_645 VSS VSS nch_25od w=33u l=0.5u
M_52 net_661 net_645 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_54 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_55 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_56 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_57 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_58 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_59 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_60 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_61 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_62 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_63 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_64 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_65 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_66 PAD net_648 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_67 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_68 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_69 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_70 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_71 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_72 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_73 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_74 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_75 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_76 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_77 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_78 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_79 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_80 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_81 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_82 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_83 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_84 PAD net_647 VDDPST net_648 pch_25od w=16.5u l=0.415u
M_85 VSS net_662 VSS VSS nch_25od w=0.5u l=3u
M_86 net_648 net_648 net_648 net_648 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_663 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_664 net_665 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_664 net_666 VSS VSS nch_25od w=5u l=0.5u
M_90 net_665 net_666 net_664 VSS nch_25od w=5u l=0.5u
M_91 net_667 net_665 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_665 net_666 net_667 VDDPST pch_25od w=5u l=0.415u
M_93 net_667 net_668 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_669 net_670 net_645 VDDPST pch_25od w=20u l=0.415u
M_95 net_669 net_671 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_645 net_671 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_670 net_645 VSS nch_25od w=15u l=0.5u
M_98 net_672 net_673 VSS VSS nch_25od w=10u l=0.5u
M_99 net_674 net_675 net_676 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_677 VSS nch_25od w=10u l=0.5u
M_101 net_678 net_675 net_679 VSS nch_25od w=10u l=0.5u
M_102 net_677 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_677 net_672 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_677 net_672 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_679 VSS nch w=10u l=0.09u
M_106 net_674 net_673 VSS VSS nch w=10u l=0.09u
M_107 net_678 I net_677 VSS nch_na25 w=5.5u l=1.32u
M_108 net_672 net_673 net_676 VSS nch_na25 w=5.5u l=1.32u
M_109 net_680 net_681 VSS VSS nch_25od w=10u l=0.5u
M_110 net_682 net_675 net_683 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_684 VSS nch_25od w=10u l=0.5u
M_112 net_685 net_675 net_686 VSS nch_25od w=10u l=0.5u
M_113 net_684 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_684 net_680 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_684 net_680 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_686 VSS nch w=10u l=0.09u
M_117 net_682 net_681 VSS VSS nch w=10u l=0.09u
M_118 net_685 OEN net_684 VSS nch_na25 w=5.5u l=1.32u
M_119 net_680 net_681 net_683 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_687 net_688 VDDPST pch_25od w=40u l=0.415u
M_121 net_688 net_689 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_690 net_687 net_688 VSS nch_25od w=20u l=0.5u
M_123 net_690 net_689 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_691 net_692 VSS nch w=3u l=0.1u
M_125 net_691 net_692 VDD VDD pch w=4u l=0.1u
M_126 net_692 net_691 net_691 VDD pch w=4u l=0.1u
M_127 net_662 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_663 net_693 VSS VSS nch_25od w=20u l=0.5u
M_129 net_662 net_691 VSS VSS nch_25od w=20u l=0.5u
M_130 net_662 net_663 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_663 net_662 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_675 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_675 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_668 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_646 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_694 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_655 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_691 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_695 net_672 VSS VSS nch_25od w=2u l=0.5u
M_142 net_695 net_672 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_689 net_680 VSS VSS nch_25od w=3u l=0.5u
M_144 net_689 net_680 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_670 net_677 VSS VSS nch_25od w=7u l=0.5u
M_146 net_670 net_677 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_687 net_695 VSS VSS nch_25od w=10u l=0.5u
M_148 net_687 net_695 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_671 net_684 VSS VSS nch_25od w=3u l=0.5u
M_150 net_671 net_684 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_673 I VSS VSS nch w=3u l=0.09u
M_152 net_673 I VDD VDD pch w=7.5u l=0.09u
M_153 net_681 OEN VSS VSS nch w=3u l=0.09u
M_154 net_681 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_693 net_691 VSS VSS nch w=3u l=0.09u
M_156 net_693 net_691 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_696 C VSS nch w=20u l=0.09u
M_158 VSS net_697 net_696 VSS nch w=10u l=0.09u
M_159 VDD net_696 C VDD pch w=30u l=0.09u
M_160 VDD net_697 net_696 VDD pch w=10u l=0.09u
M_161 VSS net_665 net_698 VSS nch_25od w=0.6u l=0.5u
M_162 net_697 net_698 VDD VSS nch_25od w=5u l=0.5u
M_163 net_699 net_689 VSS VSS nch_25od w=10u l=0.5u
M_164 net_700 net_694 net_699 VSS nch_25od w=10u l=0.5u
M_165 net_647 net_694 net_688 VSS nch_25od w=30u l=0.5u
M_166 VSS net_665 net_697 VSS nch_25od w=5u l=0.5u
M_167 net_668 net_694 net_666 VSS nch_25od w=30u l=0.5u
M_168 net_701 net_694 net_700 VSS nch_25od w=10u l=0.5u
M_169 net_666 net_671 net_701 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_665 net_698 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_700 net_694 net_668 net_648 pch_25od w=26u l=0.415u
M_172 net_647 net_700 net_688 net_648 pch_25od w=26u l=0.415u
M_173 VDD net_665 net_697 VDD pch_25od w=5u l=0.415u
M_174 net_648 net_700 VDDPST net_648 pch_25od w=24u l=0.415u
M_175 net_648 net_694 net_668 net_648 pch_25od w=24u l=0.415u
M_176 net_647 net_694 net_668 net_648 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB12SDGZ
.SUBCKT PDB16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_702 net_702 rnpolywo w=0.4u l=2.93u m=1
X_2 net_702 net_702 rnpolywo w=0.4u l=2.93u m=1
X_3 net_702 net_702 rnpolywo w=0.4u l=2.93u m=1
X_4 net_702 net_702 rnpolywo w=0.4u l=2.93u m=1
X_5 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_6 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_7 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_8 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_9 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_10 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_11 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_12 net_703 net_703 rnpolywo w=0.4u l=2.93u m=1
X_13 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_14 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_15 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_16 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_17 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_18 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_19 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_20 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_21 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_22 net_705 net_705 rppolywo w=0.4u l=1.3u m=1
X_23 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_24 net_705 net_705 rppolywo w=0.4u l=1.3u m=1
X_25 net_705 net_705 rppolywo w=0.4u l=1.3u m=1
X_26 net_705 net_705 rppolywo w=0.4u l=1.3u m=1
X_27 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
X_28 net_704 net_704 rppolywo w=0.4u l=1.3u m=1
M_29 net_706 net_702 VSS VSS nch_25od w=33u l=0.5u
M_30 net_707 net_702 VSS VSS nch_25od w=33u l=0.5u
M_31 net_708 net_702 VSS VSS nch_25od w=33u l=0.5u
M_32 net_709 net_702 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_710 net_706 VSS nch_25od w=33u l=0.5u
M_34 PAD net_710 net_707 VSS nch_25od w=33u l=0.5u
M_35 PAD net_710 net_708 VSS nch_25od w=33u l=0.5u
M_36 PAD net_710 net_709 VSS nch_25od w=33u l=0.5u
M_37 PAD net_710 net_711 VSS nch_25od w=33u l=0.5u
M_38 PAD net_710 net_712 VSS nch_25od w=33u l=0.5u
M_39 PAD net_710 net_713 VSS nch_25od w=33u l=0.5u
M_40 PAD net_710 net_714 VSS nch_25od w=33u l=0.5u
M_41 PAD net_710 net_715 VSS nch_25od w=33u l=0.5u
M_42 PAD net_710 net_716 VSS nch_25od w=33u l=0.5u
M_43 PAD net_710 net_717 VSS nch_25od w=33u l=0.5u
M_44 PAD net_710 net_718 VSS nch_25od w=33u l=0.5u
M_45 net_711 net_703 VSS VSS nch_25od w=33u l=0.5u
M_46 net_712 net_703 VSS VSS nch_25od w=33u l=0.5u
M_47 net_713 net_703 VSS VSS nch_25od w=33u l=0.5u
M_48 net_714 net_703 VSS VSS nch_25od w=33u l=0.5u
M_49 net_715 net_703 VSS VSS nch_25od w=33u l=0.5u
M_50 net_716 net_703 VSS VSS nch_25od w=33u l=0.5u
M_51 net_717 net_703 VSS VSS nch_25od w=33u l=0.5u
M_52 net_718 net_703 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_54 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_55 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_56 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_57 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_58 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_59 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_60 PAD net_705 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_61 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_62 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_63 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_64 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_65 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_66 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_67 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_68 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_69 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_70 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_71 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_72 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_73 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_74 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_75 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_76 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_77 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_78 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_79 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_80 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_81 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_82 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_83 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_84 PAD net_704 VDDPST net_705 pch_25od w=16.5u l=0.415u
M_85 VSS net_719 VSS VSS nch_25od w=0.5u l=3u
M_86 net_705 net_705 net_705 net_705 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_720 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_721 net_722 VSS VSS nch_25od w=5u l=0.5u
M_90 net_723 net_722 net_721 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_723 net_722 net_724 VDDPST pch_25od w=5u l=0.415u
M_93 net_724 net_725 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_726 net_727 net_703 VDDPST pch_25od w=20u l=0.415u
M_95 net_726 net_728 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_703 net_728 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_727 net_703 VSS nch_25od w=15u l=0.5u
M_98 net_729 net_730 VSS VSS nch_25od w=10u l=0.5u
M_99 net_731 net_732 net_733 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_734 VSS nch_25od w=10u l=0.5u
M_101 net_735 net_732 net_736 VSS nch_25od w=10u l=0.5u
M_102 net_734 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_734 net_729 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_734 net_729 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_736 VSS nch w=10u l=0.09u
M_106 net_731 net_730 VSS VSS nch w=10u l=0.09u
M_107 net_735 I net_734 VSS nch_na25 w=5.5u l=1.32u
M_108 net_729 net_730 net_733 VSS nch_na25 w=5.5u l=1.32u
M_109 net_737 net_738 VSS VSS nch_25od w=10u l=0.5u
M_110 net_739 net_732 net_740 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_741 VSS nch_25od w=10u l=0.5u
M_112 net_742 net_732 net_743 VSS nch_25od w=10u l=0.5u
M_113 net_741 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_741 net_737 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_741 net_737 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_743 VSS nch w=10u l=0.09u
M_117 net_739 net_738 VSS VSS nch w=10u l=0.09u
M_118 net_742 OEN net_741 VSS nch_na25 w=5.5u l=1.32u
M_119 net_737 net_738 net_740 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_744 net_745 VDDPST pch_25od w=40u l=0.415u
M_121 net_745 net_746 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_747 net_744 net_745 VSS nch_25od w=20u l=0.5u
M_123 net_747 net_746 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_748 net_749 VSS nch w=3u l=0.1u
M_125 net_748 net_749 VDD VDD pch w=4u l=0.1u
M_126 net_749 net_748 net_748 VDD pch w=4u l=0.1u
M_127 net_719 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_720 net_750 VSS VSS nch_25od w=20u l=0.5u
M_129 net_719 net_748 VSS VSS nch_25od w=20u l=0.5u
M_130 net_719 net_720 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_720 net_719 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_732 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_732 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_725 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_702 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_751 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_710 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_748 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_752 net_729 VSS VSS nch_25od w=2u l=0.5u
M_142 net_752 net_729 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_746 net_737 VSS VSS nch_25od w=3u l=0.5u
M_144 net_746 net_737 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_727 net_734 VSS VSS nch_25od w=7u l=0.5u
M_146 net_727 net_734 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_744 net_752 VSS VSS nch_25od w=10u l=0.5u
M_148 net_744 net_752 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_728 net_741 VSS VSS nch_25od w=3u l=0.5u
M_150 net_728 net_741 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_730 I VSS VSS nch w=3u l=0.09u
M_152 net_730 I VDD VDD pch w=7.5u l=0.09u
M_153 net_738 OEN VSS VSS nch w=3u l=0.09u
M_154 net_738 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_750 net_748 VSS VSS nch w=3u l=0.09u
M_156 net_750 net_748 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_753 C VSS nch w=20u l=0.09u
M_158 VSS net_754 net_753 VSS nch w=10u l=0.09u
M_159 VDD net_753 C VDD pch w=30u l=0.09u
M_160 VDD net_754 net_753 VDD pch w=10u l=0.09u
M_161 VSS net_723 net_755 VSS nch_25od w=0.6u l=0.5u
M_162 net_754 net_755 VDD VSS nch_25od w=5u l=0.5u
M_163 net_756 net_746 VSS VSS nch_25od w=10u l=0.5u
M_164 net_757 net_751 net_756 VSS nch_25od w=10u l=0.5u
M_165 net_704 net_751 net_745 VSS nch_25od w=30u l=0.5u
M_166 VSS net_723 net_754 VSS nch_25od w=5u l=0.5u
M_167 net_725 net_751 net_722 VSS nch_25od w=30u l=0.5u
M_168 net_758 net_751 net_757 VSS nch_25od w=10u l=0.5u
M_169 net_722 net_728 net_758 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_723 net_755 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_757 net_751 net_725 net_705 pch_25od w=26u l=0.415u
M_172 net_704 net_757 net_745 net_705 pch_25od w=26u l=0.415u
M_173 VDD net_723 net_754 VDD pch_25od w=5u l=0.415u
M_174 net_705 net_757 VDDPST net_705 pch_25od w=24u l=0.415u
M_175 net_705 net_751 net_725 net_705 pch_25od w=24u l=0.415u
M_176 net_704 net_751 net_725 net_705 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB16DGZ
.SUBCKT PDB16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_759 net_759 rnpolywo w=0.4u l=2.93u m=1
X_2 net_759 net_759 rnpolywo w=0.4u l=2.93u m=1
X_3 net_759 net_759 rnpolywo w=0.4u l=2.93u m=1
X_4 net_759 net_759 rnpolywo w=0.4u l=2.93u m=1
X_5 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_6 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_7 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_8 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_9 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_10 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_11 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_12 net_760 net_760 rnpolywo w=0.4u l=2.93u m=1
X_13 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_14 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_15 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_16 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_17 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_18 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_19 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_20 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_21 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_22 net_762 net_762 rppolywo w=0.4u l=1.3u m=1
X_23 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_24 net_762 net_762 rppolywo w=0.4u l=1.3u m=1
X_25 net_762 net_762 rppolywo w=0.4u l=1.3u m=1
X_26 net_762 net_762 rppolywo w=0.4u l=1.3u m=1
X_27 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
X_28 net_761 net_761 rppolywo w=0.4u l=1.3u m=1
M_29 net_763 net_759 VSS VSS nch_25od w=33u l=0.5u
M_30 net_764 net_759 VSS VSS nch_25od w=33u l=0.5u
M_31 net_765 net_759 VSS VSS nch_25od w=33u l=0.5u
M_32 net_766 net_759 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_767 net_763 VSS nch_25od w=33u l=0.5u
M_34 PAD net_767 net_764 VSS nch_25od w=33u l=0.5u
M_35 PAD net_767 net_765 VSS nch_25od w=33u l=0.5u
M_36 PAD net_767 net_766 VSS nch_25od w=33u l=0.5u
M_37 PAD net_767 net_768 VSS nch_25od w=33u l=0.5u
M_38 PAD net_767 net_769 VSS nch_25od w=33u l=0.5u
M_39 PAD net_767 net_770 VSS nch_25od w=33u l=0.5u
M_40 PAD net_767 net_771 VSS nch_25od w=33u l=0.5u
M_41 PAD net_767 net_772 VSS nch_25od w=33u l=0.5u
M_42 PAD net_767 net_773 VSS nch_25od w=33u l=0.5u
M_43 PAD net_767 net_774 VSS nch_25od w=33u l=0.5u
M_44 PAD net_767 net_775 VSS nch_25od w=33u l=0.5u
M_45 net_768 net_760 VSS VSS nch_25od w=33u l=0.5u
M_46 net_769 net_760 VSS VSS nch_25od w=33u l=0.5u
M_47 net_770 net_760 VSS VSS nch_25od w=33u l=0.5u
M_48 net_771 net_760 VSS VSS nch_25od w=33u l=0.5u
M_49 net_772 net_760 VSS VSS nch_25od w=33u l=0.5u
M_50 net_773 net_760 VSS VSS nch_25od w=33u l=0.5u
M_51 net_774 net_760 VSS VSS nch_25od w=33u l=0.5u
M_52 net_775 net_760 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_54 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_55 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_56 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_57 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_58 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_59 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_60 PAD net_762 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_61 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_62 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_63 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_64 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_65 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_66 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_67 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_68 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_69 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_70 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_71 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_72 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_73 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_74 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_75 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_76 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_77 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_78 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_79 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_80 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_81 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_82 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_83 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_84 PAD net_761 VDDPST net_762 pch_25od w=16.5u l=0.415u
M_85 VSS net_776 VSS VSS nch_25od w=0.5u l=3u
M_86 net_762 net_762 net_762 net_762 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_777 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_778 net_779 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_778 net_780 VSS VSS nch_25od w=5u l=0.5u
M_90 net_779 net_780 net_778 VSS nch_25od w=5u l=0.5u
M_91 net_781 net_779 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_779 net_780 net_781 VDDPST pch_25od w=5u l=0.415u
M_93 net_781 net_782 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_783 net_784 net_760 VDDPST pch_25od w=20u l=0.415u
M_95 net_783 net_785 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_760 net_785 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_784 net_760 VSS nch_25od w=15u l=0.5u
M_98 net_786 net_787 VSS VSS nch_25od w=10u l=0.5u
M_99 net_788 net_789 net_790 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_791 VSS nch_25od w=10u l=0.5u
M_101 net_792 net_789 net_793 VSS nch_25od w=10u l=0.5u
M_102 net_791 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_791 net_786 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_791 net_786 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_793 VSS nch w=10u l=0.09u
M_106 net_788 net_787 VSS VSS nch w=10u l=0.09u
M_107 net_792 I net_791 VSS nch_na25 w=5.5u l=1.32u
M_108 net_786 net_787 net_790 VSS nch_na25 w=5.5u l=1.32u
M_109 net_794 net_795 VSS VSS nch_25od w=10u l=0.5u
M_110 net_796 net_789 net_797 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_798 VSS nch_25od w=10u l=0.5u
M_112 net_799 net_789 net_800 VSS nch_25od w=10u l=0.5u
M_113 net_798 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_798 net_794 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_798 net_794 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_800 VSS nch w=10u l=0.09u
M_117 net_796 net_795 VSS VSS nch w=10u l=0.09u
M_118 net_799 OEN net_798 VSS nch_na25 w=5.5u l=1.32u
M_119 net_794 net_795 net_797 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_801 net_802 VDDPST pch_25od w=40u l=0.415u
M_121 net_802 net_803 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_804 net_801 net_802 VSS nch_25od w=20u l=0.5u
M_123 net_804 net_803 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_805 net_806 VSS nch w=3u l=0.1u
M_125 net_805 net_806 VDD VDD pch w=4u l=0.1u
M_126 net_806 net_805 net_805 VDD pch w=4u l=0.1u
M_127 net_776 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_777 net_807 VSS VSS nch_25od w=20u l=0.5u
M_129 net_776 net_805 VSS VSS nch_25od w=20u l=0.5u
M_130 net_776 net_777 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_777 net_776 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_789 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_789 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_782 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_759 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_808 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_767 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_805 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_809 net_786 VSS VSS nch_25od w=2u l=0.5u
M_142 net_809 net_786 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_803 net_794 VSS VSS nch_25od w=3u l=0.5u
M_144 net_803 net_794 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_784 net_791 VSS VSS nch_25od w=7u l=0.5u
M_146 net_784 net_791 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_801 net_809 VSS VSS nch_25od w=10u l=0.5u
M_148 net_801 net_809 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_785 net_798 VSS VSS nch_25od w=3u l=0.5u
M_150 net_785 net_798 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_787 I VSS VSS nch w=3u l=0.09u
M_152 net_787 I VDD VDD pch w=7.5u l=0.09u
M_153 net_795 OEN VSS VSS nch w=3u l=0.09u
M_154 net_795 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_807 net_805 VSS VSS nch w=3u l=0.09u
M_156 net_807 net_805 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_810 C VSS nch w=20u l=0.09u
M_158 VSS net_811 net_810 VSS nch w=10u l=0.09u
M_159 VDD net_810 C VDD pch w=30u l=0.09u
M_160 VDD net_811 net_810 VDD pch w=10u l=0.09u
M_161 VSS net_779 net_812 VSS nch_25od w=0.6u l=0.5u
M_162 net_811 net_812 VDD VSS nch_25od w=5u l=0.5u
M_163 net_813 net_803 VSS VSS nch_25od w=10u l=0.5u
M_164 net_814 net_808 net_813 VSS nch_25od w=10u l=0.5u
M_165 net_761 net_808 net_802 VSS nch_25od w=30u l=0.5u
M_166 VSS net_779 net_811 VSS nch_25od w=5u l=0.5u
M_167 net_782 net_808 net_780 VSS nch_25od w=30u l=0.5u
M_168 net_815 net_808 net_814 VSS nch_25od w=10u l=0.5u
M_169 net_780 net_785 net_815 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_779 net_812 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_814 net_808 net_782 net_762 pch_25od w=26u l=0.415u
M_172 net_761 net_814 net_802 net_762 pch_25od w=26u l=0.415u
M_173 VDD net_779 net_811 VDD pch_25od w=5u l=0.415u
M_174 net_762 net_814 VDDPST net_762 pch_25od w=24u l=0.415u
M_175 net_762 net_808 net_782 net_762 pch_25od w=24u l=0.415u
M_176 net_761 net_808 net_782 net_762 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB16SDGZ
.SUBCKT PDB24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_2 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_3 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_4 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_5 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_6 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_7 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_8 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_9 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_10 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_11 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_12 net_816 net_816 rnpolywo w=0.4u l=2.93u m=1
X_13 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_14 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_15 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_16 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_17 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_18 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_19 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_20 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_21 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_22 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_23 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_24 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_25 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_26 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_27 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
X_28 net_817 net_817 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_818 net_819 VSS nch_25od w=33u l=0.5u
M_30 PAD net_818 net_820 VSS nch_25od w=33u l=0.5u
M_31 PAD net_818 net_821 VSS nch_25od w=33u l=0.5u
M_32 PAD net_818 net_822 VSS nch_25od w=33u l=0.5u
M_33 PAD net_818 net_823 VSS nch_25od w=33u l=0.5u
M_34 PAD net_818 net_824 VSS nch_25od w=33u l=0.5u
M_35 PAD net_818 net_825 VSS nch_25od w=33u l=0.5u
M_36 PAD net_818 net_826 VSS nch_25od w=33u l=0.5u
M_37 PAD net_818 net_827 VSS nch_25od w=33u l=0.5u
M_38 PAD net_818 net_828 VSS nch_25od w=33u l=0.5u
M_39 PAD net_818 net_829 VSS nch_25od w=33u l=0.5u
M_40 PAD net_818 net_830 VSS nch_25od w=33u l=0.5u
M_41 net_819 net_816 VSS VSS nch_25od w=33u l=0.5u
M_42 net_820 net_816 VSS VSS nch_25od w=33u l=0.5u
M_43 net_821 net_816 VSS VSS nch_25od w=33u l=0.5u
M_44 net_822 net_816 VSS VSS nch_25od w=33u l=0.5u
M_45 net_823 net_816 VSS VSS nch_25od w=33u l=0.5u
M_46 net_824 net_816 VSS VSS nch_25od w=33u l=0.5u
M_47 net_825 net_816 VSS VSS nch_25od w=33u l=0.5u
M_48 net_826 net_816 VSS VSS nch_25od w=33u l=0.5u
M_49 net_827 net_816 VSS VSS nch_25od w=33u l=0.5u
M_50 net_828 net_816 VSS VSS nch_25od w=33u l=0.5u
M_51 net_829 net_816 VSS VSS nch_25od w=33u l=0.5u
M_52 net_830 net_816 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_54 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_55 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_56 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_57 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_58 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_59 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_60 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_61 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_62 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_63 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_64 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_65 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_66 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_67 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_68 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_69 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_70 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_71 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_72 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_73 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_74 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_75 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_76 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_77 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_78 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_79 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_80 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_81 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_82 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_83 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_84 PAD net_817 VDDPST net_831 pch_25od w=16.5u l=0.415u
M_85 VSS net_832 VSS VSS nch_25od w=0.5u l=3u
M_86 net_831 net_831 net_831 net_831 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_833 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_834 net_835 VSS VSS nch_25od w=5u l=0.5u
M_90 net_836 net_835 net_834 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_836 net_835 net_837 VDDPST pch_25od w=5u l=0.415u
M_93 net_837 net_838 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_839 net_840 net_816 VDDPST pch_25od w=20u l=0.415u
M_95 net_839 net_841 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_816 net_841 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_840 net_816 VSS nch_25od w=15u l=0.5u
M_98 net_842 net_843 VSS VSS nch_25od w=10u l=0.5u
M_99 net_844 net_845 net_846 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_847 VSS nch_25od w=10u l=0.5u
M_101 net_848 net_845 net_849 VSS nch_25od w=10u l=0.5u
M_102 net_847 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_847 net_842 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_847 net_842 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_849 VSS nch w=10u l=0.09u
M_106 net_844 net_843 VSS VSS nch w=10u l=0.09u
M_107 net_848 I net_847 VSS nch_na25 w=5.5u l=1.32u
M_108 net_842 net_843 net_846 VSS nch_na25 w=5.5u l=1.32u
M_109 net_850 net_851 VSS VSS nch_25od w=10u l=0.5u
M_110 net_852 net_845 net_853 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_854 VSS nch_25od w=10u l=0.5u
M_112 net_855 net_845 net_856 VSS nch_25od w=10u l=0.5u
M_113 net_854 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_854 net_850 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_854 net_850 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_856 VSS nch w=10u l=0.09u
M_117 net_852 net_851 VSS VSS nch w=10u l=0.09u
M_118 net_855 OEN net_854 VSS nch_na25 w=5.5u l=1.32u
M_119 net_850 net_851 net_853 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_857 net_858 VDDPST pch_25od w=40u l=0.415u
M_121 net_858 net_859 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_860 net_857 net_858 VSS nch_25od w=20u l=0.5u
M_123 net_860 net_859 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_861 net_862 VSS nch w=3u l=0.1u
M_125 net_861 net_862 VDD VDD pch w=4u l=0.1u
M_126 net_862 net_861 net_861 VDD pch w=4u l=0.1u
M_127 net_832 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_833 net_863 VSS VSS nch_25od w=20u l=0.5u
M_129 net_832 net_861 VSS VSS nch_25od w=20u l=0.5u
M_130 net_832 net_833 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_833 net_832 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_845 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_845 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_838 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_864 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_865 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_818 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_861 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_866 net_842 VSS VSS nch_25od w=2u l=0.5u
M_142 net_866 net_842 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_859 net_850 VSS VSS nch_25od w=3u l=0.5u
M_144 net_859 net_850 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_840 net_847 VSS VSS nch_25od w=7u l=0.5u
M_146 net_840 net_847 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_857 net_866 VSS VSS nch_25od w=10u l=0.5u
M_148 net_857 net_866 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_841 net_854 VSS VSS nch_25od w=3u l=0.5u
M_150 net_841 net_854 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_843 I VSS VSS nch w=3u l=0.09u
M_152 net_843 I VDD VDD pch w=7.5u l=0.09u
M_153 net_851 OEN VSS VSS nch w=3u l=0.09u
M_154 net_851 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_863 net_861 VSS VSS nch w=3u l=0.09u
M_156 net_863 net_861 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_867 C VSS nch w=20u l=0.09u
M_158 VSS net_868 net_867 VSS nch w=10u l=0.09u
M_159 VDD net_867 C VDD pch w=30u l=0.09u
M_160 VDD net_868 net_867 VDD pch w=10u l=0.09u
M_161 VSS net_836 net_869 VSS nch_25od w=0.6u l=0.5u
M_162 net_868 net_869 VDD VSS nch_25od w=5u l=0.5u
M_163 net_870 net_859 VSS VSS nch_25od w=10u l=0.5u
M_164 net_871 net_865 net_870 VSS nch_25od w=10u l=0.5u
M_165 net_817 net_865 net_858 VSS nch_25od w=30u l=0.5u
M_166 VSS net_836 net_868 VSS nch_25od w=5u l=0.5u
M_167 net_838 net_865 net_835 VSS nch_25od w=30u l=0.5u
M_168 net_872 net_865 net_871 VSS nch_25od w=10u l=0.5u
M_169 net_835 net_841 net_872 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_836 net_869 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_871 net_865 net_838 net_831 pch_25od w=26u l=0.415u
M_172 net_817 net_871 net_858 net_831 pch_25od w=26u l=0.415u
M_173 VDD net_836 net_868 VDD pch_25od w=5u l=0.415u
M_174 net_831 net_871 VDDPST net_831 pch_25od w=24u l=0.415u
M_175 net_831 net_865 net_838 net_831 pch_25od w=24u l=0.415u
M_176 net_817 net_865 net_838 net_831 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB24DGZ
.SUBCKT PDB24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_2 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_3 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_4 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_5 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_6 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_7 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_8 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_9 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_10 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_11 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_12 net_873 net_873 rnpolywo w=0.4u l=2.93u m=1
X_13 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_14 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_15 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_16 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_17 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_18 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_19 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_20 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_21 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_22 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_23 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_24 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_25 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_26 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_27 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
X_28 net_874 net_874 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_875 net_876 VSS nch_25od w=33u l=0.5u
M_30 PAD net_875 net_877 VSS nch_25od w=33u l=0.5u
M_31 PAD net_875 net_878 VSS nch_25od w=33u l=0.5u
M_32 PAD net_875 net_879 VSS nch_25od w=33u l=0.5u
M_33 PAD net_875 net_880 VSS nch_25od w=33u l=0.5u
M_34 PAD net_875 net_881 VSS nch_25od w=33u l=0.5u
M_35 PAD net_875 net_882 VSS nch_25od w=33u l=0.5u
M_36 PAD net_875 net_883 VSS nch_25od w=33u l=0.5u
M_37 PAD net_875 net_884 VSS nch_25od w=33u l=0.5u
M_38 PAD net_875 net_885 VSS nch_25od w=33u l=0.5u
M_39 PAD net_875 net_886 VSS nch_25od w=33u l=0.5u
M_40 PAD net_875 net_887 VSS nch_25od w=33u l=0.5u
M_41 net_876 net_873 VSS VSS nch_25od w=33u l=0.5u
M_42 net_877 net_873 VSS VSS nch_25od w=33u l=0.5u
M_43 net_878 net_873 VSS VSS nch_25od w=33u l=0.5u
M_44 net_879 net_873 VSS VSS nch_25od w=33u l=0.5u
M_45 net_880 net_873 VSS VSS nch_25od w=33u l=0.5u
M_46 net_881 net_873 VSS VSS nch_25od w=33u l=0.5u
M_47 net_882 net_873 VSS VSS nch_25od w=33u l=0.5u
M_48 net_883 net_873 VSS VSS nch_25od w=33u l=0.5u
M_49 net_884 net_873 VSS VSS nch_25od w=33u l=0.5u
M_50 net_885 net_873 VSS VSS nch_25od w=33u l=0.5u
M_51 net_886 net_873 VSS VSS nch_25od w=33u l=0.5u
M_52 net_887 net_873 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_54 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_55 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_56 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_57 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_58 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_59 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_60 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_61 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_62 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_63 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_64 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_65 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_66 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_67 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_68 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_69 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_70 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_71 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_72 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_73 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_74 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_75 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_76 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_77 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_78 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_79 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_80 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_81 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_82 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_83 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_84 PAD net_874 VDDPST net_888 pch_25od w=16.5u l=0.415u
M_85 VSS net_889 VSS VSS nch_25od w=0.5u l=3u
M_86 net_888 net_888 net_888 net_888 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_890 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_891 net_892 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_891 net_893 VSS VSS nch_25od w=5u l=0.5u
M_90 net_892 net_893 net_891 VSS nch_25od w=5u l=0.5u
M_91 net_894 net_892 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_892 net_893 net_894 VDDPST pch_25od w=5u l=0.415u
M_93 net_894 net_895 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_896 net_897 net_873 VDDPST pch_25od w=20u l=0.415u
M_95 net_896 net_898 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_873 net_898 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_897 net_873 VSS nch_25od w=15u l=0.5u
M_98 net_899 net_900 VSS VSS nch_25od w=10u l=0.5u
M_99 net_901 net_902 net_903 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_904 VSS nch_25od w=10u l=0.5u
M_101 net_905 net_902 net_906 VSS nch_25od w=10u l=0.5u
M_102 net_904 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_904 net_899 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_904 net_899 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_906 VSS nch w=10u l=0.09u
M_106 net_901 net_900 VSS VSS nch w=10u l=0.09u
M_107 net_905 I net_904 VSS nch_na25 w=5.5u l=1.32u
M_108 net_899 net_900 net_903 VSS nch_na25 w=5.5u l=1.32u
M_109 net_907 net_908 VSS VSS nch_25od w=10u l=0.5u
M_110 net_909 net_902 net_910 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_911 VSS nch_25od w=10u l=0.5u
M_112 net_912 net_902 net_913 VSS nch_25od w=10u l=0.5u
M_113 net_911 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_911 net_907 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_911 net_907 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_913 VSS nch w=10u l=0.09u
M_117 net_909 net_908 VSS VSS nch w=10u l=0.09u
M_118 net_912 OEN net_911 VSS nch_na25 w=5.5u l=1.32u
M_119 net_907 net_908 net_910 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_914 net_915 VDDPST pch_25od w=40u l=0.415u
M_121 net_915 net_916 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_917 net_914 net_915 VSS nch_25od w=20u l=0.5u
M_123 net_917 net_916 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_918 net_919 VSS nch w=3u l=0.1u
M_125 net_918 net_919 VDD VDD pch w=4u l=0.1u
M_126 net_919 net_918 net_918 VDD pch w=4u l=0.1u
M_127 net_889 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_890 net_920 VSS VSS nch_25od w=20u l=0.5u
M_129 net_889 net_918 VSS VSS nch_25od w=20u l=0.5u
M_130 net_889 net_890 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_890 net_889 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_902 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_902 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_895 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_921 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_922 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_875 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_918 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_923 net_899 VSS VSS nch_25od w=2u l=0.5u
M_142 net_923 net_899 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_916 net_907 VSS VSS nch_25od w=3u l=0.5u
M_144 net_916 net_907 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_897 net_904 VSS VSS nch_25od w=7u l=0.5u
M_146 net_897 net_904 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_914 net_923 VSS VSS nch_25od w=10u l=0.5u
M_148 net_914 net_923 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_898 net_911 VSS VSS nch_25od w=3u l=0.5u
M_150 net_898 net_911 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_900 I VSS VSS nch w=3u l=0.09u
M_152 net_900 I VDD VDD pch w=7.5u l=0.09u
M_153 net_908 OEN VSS VSS nch w=3u l=0.09u
M_154 net_908 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_920 net_918 VSS VSS nch w=3u l=0.09u
M_156 net_920 net_918 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_924 C VSS nch w=20u l=0.09u
M_158 VSS net_925 net_924 VSS nch w=10u l=0.09u
M_159 VDD net_924 C VDD pch w=30u l=0.09u
M_160 VDD net_925 net_924 VDD pch w=10u l=0.09u
M_161 VSS net_892 net_926 VSS nch_25od w=0.6u l=0.5u
M_162 net_925 net_926 VDD VSS nch_25od w=5u l=0.5u
M_163 net_927 net_916 VSS VSS nch_25od w=10u l=0.5u
M_164 net_928 net_922 net_927 VSS nch_25od w=10u l=0.5u
M_165 net_874 net_922 net_915 VSS nch_25od w=30u l=0.5u
M_166 VSS net_892 net_925 VSS nch_25od w=5u l=0.5u
M_167 net_895 net_922 net_893 VSS nch_25od w=30u l=0.5u
M_168 net_929 net_922 net_928 VSS nch_25od w=10u l=0.5u
M_169 net_893 net_898 net_929 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_892 net_926 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_928 net_922 net_895 net_888 pch_25od w=26u l=0.415u
M_172 net_874 net_928 net_915 net_888 pch_25od w=26u l=0.415u
M_173 VDD net_892 net_925 VDD pch_25od w=5u l=0.415u
M_174 net_888 net_928 VDDPST net_888 pch_25od w=24u l=0.415u
M_175 net_888 net_922 net_895 net_888 pch_25od w=24u l=0.415u
M_176 net_874 net_922 net_895 net_888 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDB24SDGZ
.SUBCKT PDD02DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_2 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_3 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_4 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_5 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_6 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_7 net_931 net_931 rnpolywo w=0.4u l=2.93u m=1
X_8 net_931 net_931 rnpolywo w=0.4u l=2.93u m=1
X_9 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_10 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_11 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_12 net_930 net_930 rnpolywo w=0.4u l=2.93u m=1
X_13 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_14 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_15 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_16 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_17 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_18 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_19 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_20 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_21 net_933 net_933 rppolywo w=0.4u l=1.3u m=1
X_22 net_933 net_933 rppolywo w=0.4u l=1.3u m=1
X_23 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_24 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_25 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_26 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_27 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
X_28 net_932 net_932 rppolywo w=0.4u l=1.3u m=1
M_29 net_934 net_930 VSS VSS nch_25od w=33u l=0.5u
M_30 net_935 net_930 VSS VSS nch_25od w=33u l=0.5u
M_31 net_936 net_930 VSS VSS nch_25od w=33u l=0.5u
M_32 net_937 net_930 VSS VSS nch_25od w=33u l=0.5u
M_33 net_938 net_930 VSS VSS nch_25od w=33u l=0.5u
M_34 net_939 net_930 VSS VSS nch_25od w=33u l=0.5u
M_35 net_940 net_930 VSS VSS nch_25od w=33u l=0.5u
M_36 net_941 net_930 VSS VSS nch_25od w=33u l=0.5u
M_37 net_942 net_930 VSS VSS nch_25od w=33u l=0.5u
M_38 net_943 net_930 VSS VSS nch_25od w=33u l=0.5u
M_39 net_944 net_930 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_945 net_934 VSS nch_25od w=33u l=0.5u
M_41 PAD net_945 net_935 VSS nch_25od w=33u l=0.5u
M_42 PAD net_945 net_936 VSS nch_25od w=33u l=0.5u
M_43 PAD net_945 net_937 VSS nch_25od w=33u l=0.5u
M_44 PAD net_945 net_938 VSS nch_25od w=33u l=0.5u
M_45 PAD net_945 net_939 VSS nch_25od w=33u l=0.5u
M_46 PAD net_945 net_940 VSS nch_25od w=33u l=0.5u
M_47 PAD net_945 net_941 VSS nch_25od w=33u l=0.5u
M_48 PAD net_945 net_942 VSS nch_25od w=33u l=0.5u
M_49 PAD net_945 net_943 VSS nch_25od w=33u l=0.5u
M_50 PAD net_945 net_944 VSS nch_25od w=33u l=0.5u
M_51 PAD net_945 net_946 VSS nch_25od w=33u l=0.5u
M_52 net_946 net_931 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_54 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_55 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_56 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_57 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_58 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_59 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_60 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_61 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_62 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_63 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_64 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_65 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_66 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_67 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_68 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_69 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_70 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_71 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_72 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_73 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_74 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_75 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_76 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_77 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_78 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_79 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_80 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_81 PAD net_932 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_82 PAD net_933 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_83 PAD net_933 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_84 PAD net_933 VDDPST net_932 pch_25od w=16.5u l=0.415u
M_85 net_947 net_948 VSS VSS nch_25od w=0.5u l=3u
M_86 net_932 net_932 net_932 net_932 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_949 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_950 net_947 VSS VSS nch_25od w=5u l=0.5u
M_90 net_951 net_947 net_950 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_951 net_947 net_952 VDDPST pch_25od w=5u l=0.415u
M_93 net_952 net_953 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_954 net_955 net_931 VDDPST pch_25od w=20u l=0.415u
M_95 net_954 net_956 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_931 net_956 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_955 net_931 VSS nch_25od w=15u l=0.5u
M_98 net_957 net_958 VSS VSS nch_25od w=10u l=0.5u
M_99 net_959 net_960 net_961 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_962 VSS nch_25od w=10u l=0.5u
M_101 net_963 net_960 net_964 VSS nch_25od w=10u l=0.5u
M_102 net_962 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_962 net_957 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_962 net_957 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_964 VSS nch w=10u l=0.09u
M_106 net_959 net_958 VSS VSS nch w=10u l=0.09u
M_107 net_963 I net_962 VSS nch_na25 w=5.5u l=1.32u
M_108 net_957 net_958 net_961 VSS nch_na25 w=5.5u l=1.32u
M_109 net_965 net_966 VSS VSS nch_25od w=10u l=0.5u
M_110 net_967 net_960 net_968 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_969 VSS nch_25od w=10u l=0.5u
M_112 net_970 net_960 net_971 VSS nch_25od w=10u l=0.5u
M_113 net_969 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_969 net_965 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_969 net_965 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_971 VSS nch w=10u l=0.09u
M_117 net_967 net_966 VSS VSS nch w=10u l=0.09u
M_118 net_970 OEN net_969 VSS nch_na25 w=5.5u l=1.32u
M_119 net_965 net_966 net_968 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_972 net_973 VDDPST pch_25od w=40u l=0.415u
M_121 net_973 net_974 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_975 net_972 net_973 VSS nch_25od w=20u l=0.5u
M_123 net_975 net_974 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_976 net_977 VSS nch w=3u l=0.1u
M_125 net_976 net_977 VDD VDD pch w=4u l=0.1u
M_126 net_977 net_976 net_976 VDD pch w=4u l=0.1u
M_127 net_948 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_949 net_978 VSS VSS nch_25od w=20u l=0.5u
M_129 net_948 net_977 VSS VSS nch_25od w=20u l=0.5u
M_130 net_948 net_949 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_949 net_948 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_960 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_960 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_953 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_930 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_979 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_945 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_977 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_980 net_957 VSS VSS nch_25od w=2u l=0.5u
M_142 net_980 net_957 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_974 net_965 VSS VSS nch_25od w=3u l=0.5u
M_144 net_974 net_965 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_955 net_962 VSS VSS nch_25od w=7u l=0.5u
M_146 net_955 net_962 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_972 net_980 VSS VSS nch_25od w=10u l=0.5u
M_148 net_972 net_980 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_956 net_969 VSS VSS nch_25od w=3u l=0.5u
M_150 net_956 net_969 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_958 I VSS VSS nch w=3u l=0.09u
M_152 net_958 I VDD VDD pch w=7.5u l=0.09u
M_153 net_966 OEN VSS VSS nch w=3u l=0.09u
M_154 net_966 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_978 net_977 VSS VSS nch w=3u l=0.09u
M_156 net_978 net_977 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_981 C VSS nch w=20u l=0.09u
M_158 VSS net_982 net_981 VSS nch w=10u l=0.09u
M_159 VDD net_981 C VDD pch w=30u l=0.09u
M_160 VDD net_982 net_981 VDD pch w=10u l=0.09u
M_161 VSS net_951 net_983 VSS nch_25od w=0.6u l=0.5u
M_162 net_982 net_983 VDD VSS nch_25od w=5u l=0.5u
M_163 net_984 net_974 VSS VSS nch_25od w=10u l=0.5u
M_164 net_985 net_979 net_984 VSS nch_25od w=10u l=0.5u
M_165 net_933 net_979 net_973 VSS nch_25od w=30u l=0.5u
M_166 VSS net_951 net_982 VSS nch_25od w=5u l=0.5u
M_167 net_953 net_979 net_947 VSS nch_25od w=30u l=0.5u
M_168 net_986 net_979 net_985 VSS nch_25od w=10u l=0.5u
M_169 net_947 net_956 net_986 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_951 net_983 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_985 net_979 net_953 net_932 pch_25od w=26u l=0.415u
M_172 net_933 net_985 net_973 net_932 pch_25od w=26u l=0.415u
M_173 VDD net_951 net_982 VDD pch_25od w=5u l=0.415u
M_174 net_932 net_985 VDDPST net_932 pch_25od w=24u l=0.415u
M_175 net_932 net_979 net_953 net_932 pch_25od w=24u l=0.415u
M_176 net_933 net_979 net_953 net_932 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD02DGZ
.SUBCKT PDD02SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_2 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_3 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_4 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_5 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_6 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_7 net_988 net_988 rnpolywo w=0.4u l=2.93u m=1
X_8 net_988 net_988 rnpolywo w=0.4u l=2.93u m=1
X_9 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_10 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_11 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_12 net_987 net_987 rnpolywo w=0.4u l=2.93u m=1
X_13 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_14 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_15 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_16 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_17 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_18 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_19 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_20 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_21 net_990 net_990 rppolywo w=0.4u l=1.3u m=1
X_22 net_990 net_990 rppolywo w=0.4u l=1.3u m=1
X_23 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_24 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_25 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_26 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_27 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
X_28 net_989 net_989 rppolywo w=0.4u l=1.3u m=1
M_29 net_991 net_987 VSS VSS nch_25od w=33u l=0.5u
M_30 net_992 net_987 VSS VSS nch_25od w=33u l=0.5u
M_31 net_993 net_987 VSS VSS nch_25od w=33u l=0.5u
M_32 net_994 net_987 VSS VSS nch_25od w=33u l=0.5u
M_33 net_995 net_987 VSS VSS nch_25od w=33u l=0.5u
M_34 net_996 net_987 VSS VSS nch_25od w=33u l=0.5u
M_35 net_997 net_987 VSS VSS nch_25od w=33u l=0.5u
M_36 net_998 net_987 VSS VSS nch_25od w=33u l=0.5u
M_37 net_999 net_987 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1000 net_987 VSS VSS nch_25od w=33u l=0.5u
M_39 net_1001 net_987 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_1002 net_991 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1002 net_992 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1002 net_993 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1002 net_994 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1002 net_995 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1002 net_996 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1002 net_997 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1002 net_998 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1002 net_999 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1002 net_1000 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1002 net_1001 VSS nch_25od w=33u l=0.5u
M_51 PAD net_1002 net_1003 VSS nch_25od w=33u l=0.5u
M_52 net_1003 net_988 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_54 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_55 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_56 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_57 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_58 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_59 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_60 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_61 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_62 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_63 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_64 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_65 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_66 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_67 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_68 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_69 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_70 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_71 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_72 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_73 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_74 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_75 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_76 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_77 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_78 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_79 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_80 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_81 PAD net_989 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_82 PAD net_990 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_83 PAD net_990 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_84 PAD net_990 VDDPST net_989 pch_25od w=16.5u l=0.415u
M_85 net_1004 net_1005 VSS VSS nch_25od w=0.5u l=3u
M_86 net_989 net_989 net_989 net_989 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1006 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1007 net_1008 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1007 net_1004 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1008 net_1004 net_1007 VSS nch_25od w=5u l=0.5u
M_91 net_1009 net_1008 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1008 net_1004 net_1009 VDDPST pch_25od w=5u l=0.415u
M_93 net_1009 net_1010 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1011 net_1012 net_988 VDDPST pch_25od w=20u l=0.415u
M_95 net_1011 net_1013 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_988 net_1013 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1012 net_988 VSS nch_25od w=15u l=0.5u
M_98 net_1014 net_1015 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1016 net_1017 net_1018 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1019 VSS nch_25od w=10u l=0.5u
M_101 net_1020 net_1017 net_1021 VSS nch_25od w=10u l=0.5u
M_102 net_1019 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1019 net_1014 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1019 net_1014 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1021 VSS nch w=10u l=0.09u
M_106 net_1016 net_1015 VSS VSS nch w=10u l=0.09u
M_107 net_1020 I net_1019 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1014 net_1015 net_1018 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1022 net_1023 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1024 net_1017 net_1025 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1026 VSS nch_25od w=10u l=0.5u
M_112 net_1027 net_1017 net_1028 VSS nch_25od w=10u l=0.5u
M_113 net_1026 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1026 net_1022 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1026 net_1022 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1028 VSS nch w=10u l=0.09u
M_117 net_1024 net_1023 VSS VSS nch w=10u l=0.09u
M_118 net_1027 OEN net_1026 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1022 net_1023 net_1025 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1029 net_1030 VDDPST pch_25od w=40u l=0.415u
M_121 net_1030 net_1031 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1032 net_1029 net_1030 VSS nch_25od w=20u l=0.5u
M_123 net_1032 net_1031 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1033 net_1034 VSS nch w=3u l=0.1u
M_125 net_1033 net_1034 VDD VDD pch w=4u l=0.1u
M_126 net_1034 net_1033 net_1033 VDD pch w=4u l=0.1u
M_127 net_1005 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1006 net_1035 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1005 net_1034 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1005 net_1006 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1006 net_1005 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1017 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1017 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1010 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_987 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1036 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1002 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1034 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1037 net_1014 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1037 net_1014 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1031 net_1022 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1031 net_1022 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1012 net_1019 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1012 net_1019 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1029 net_1037 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1029 net_1037 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1013 net_1026 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1013 net_1026 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1015 I VSS VSS nch w=3u l=0.09u
M_152 net_1015 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1023 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1023 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1035 net_1034 VSS VSS nch w=3u l=0.09u
M_156 net_1035 net_1034 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1038 C VSS nch w=20u l=0.09u
M_158 VSS net_1039 net_1038 VSS nch w=10u l=0.09u
M_159 VDD net_1038 C VDD pch w=30u l=0.09u
M_160 VDD net_1039 net_1038 VDD pch w=10u l=0.09u
M_161 VSS net_1008 net_1040 VSS nch_25od w=0.6u l=0.5u
M_162 net_1039 net_1040 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1041 net_1031 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1042 net_1036 net_1041 VSS nch_25od w=10u l=0.5u
M_165 net_990 net_1036 net_1030 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1008 net_1039 VSS nch_25od w=5u l=0.5u
M_167 net_1010 net_1036 net_1004 VSS nch_25od w=30u l=0.5u
M_168 net_1043 net_1036 net_1042 VSS nch_25od w=10u l=0.5u
M_169 net_1004 net_1013 net_1043 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1008 net_1040 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1042 net_1036 net_1010 net_989 pch_25od w=26u l=0.415u
M_172 net_990 net_1042 net_1030 net_989 pch_25od w=26u l=0.415u
M_173 VDD net_1008 net_1039 VDD pch_25od w=5u l=0.415u
M_174 net_989 net_1042 VDDPST net_989 pch_25od w=24u l=0.415u
M_175 net_989 net_1036 net_1010 net_989 pch_25od w=24u l=0.415u
M_176 net_990 net_1036 net_1010 net_989 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD02SDGZ
.SUBCKT PDD04DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1045 net_1045 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1045 net_1045 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1044 net_1044 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_14 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_15 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_16 net_1047 net_1047 rppolywo w=0.4u l=1.3u m=1
X_17 net_1047 net_1047 rppolywo w=0.4u l=1.3u m=1
X_18 net_1047 net_1047 rppolywo w=0.4u l=1.3u m=1
X_19 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_20 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_21 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_22 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_23 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_24 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_25 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_26 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_27 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
X_28 net_1046 net_1046 rppolywo w=0.4u l=1.3u m=1
M_29 net_1048 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1049 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1050 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1051 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1052 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1053 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1054 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1055 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1056 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1057 net_1044 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_1058 net_1048 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1058 net_1049 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1058 net_1050 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1058 net_1051 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1058 net_1052 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1058 net_1053 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1058 net_1054 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1058 net_1055 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1058 net_1056 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1058 net_1057 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1058 net_1059 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1058 net_1060 VSS nch_25od w=33u l=0.5u
M_51 net_1059 net_1045 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1060 net_1045 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_54 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_55 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_56 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_57 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_58 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_59 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_60 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_61 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_62 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_63 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_64 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_65 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_66 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_67 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_68 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_69 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_70 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_71 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_72 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_73 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_74 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_75 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_76 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_77 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_78 PAD net_1046 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_79 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_80 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_81 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_82 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_83 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_84 PAD net_1047 VDDPST net_1046 pch_25od w=16.5u l=0.415u
M_85 net_1061 net_1062 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1046 net_1046 net_1046 net_1046 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1063 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1064 net_1061 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1065 net_1061 net_1064 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1065 net_1061 net_1066 VDDPST pch_25od w=5u l=0.415u
M_93 net_1066 net_1067 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1068 net_1069 net_1045 VDDPST pch_25od w=20u l=0.415u
M_95 net_1068 net_1070 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1045 net_1070 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1069 net_1045 VSS nch_25od w=15u l=0.5u
M_98 net_1071 net_1072 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1073 net_1074 net_1075 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1076 VSS nch_25od w=10u l=0.5u
M_101 net_1077 net_1074 net_1078 VSS nch_25od w=10u l=0.5u
M_102 net_1076 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1076 net_1071 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1076 net_1071 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1078 VSS nch w=10u l=0.09u
M_106 net_1073 net_1072 VSS VSS nch w=10u l=0.09u
M_107 net_1077 I net_1076 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1071 net_1072 net_1075 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1079 net_1080 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1081 net_1074 net_1082 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1083 VSS nch_25od w=10u l=0.5u
M_112 net_1084 net_1074 net_1085 VSS nch_25od w=10u l=0.5u
M_113 net_1083 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1083 net_1079 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1083 net_1079 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1085 VSS nch w=10u l=0.09u
M_117 net_1081 net_1080 VSS VSS nch w=10u l=0.09u
M_118 net_1084 OEN net_1083 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1079 net_1080 net_1082 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1086 net_1087 VDDPST pch_25od w=40u l=0.415u
M_121 net_1087 net_1088 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1089 net_1086 net_1087 VSS nch_25od w=20u l=0.5u
M_123 net_1089 net_1088 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1090 net_1091 VSS nch w=3u l=0.1u
M_125 net_1090 net_1091 VDD VDD pch w=4u l=0.1u
M_126 net_1091 net_1090 net_1090 VDD pch w=4u l=0.1u
M_127 net_1062 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1063 net_1092 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1062 net_1091 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1062 net_1063 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1063 net_1062 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1074 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1074 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1067 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1044 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1093 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1058 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1091 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1094 net_1071 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1094 net_1071 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1088 net_1079 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1088 net_1079 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1069 net_1076 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1069 net_1076 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1086 net_1094 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1086 net_1094 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1070 net_1083 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1070 net_1083 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1072 I VSS VSS nch w=3u l=0.09u
M_152 net_1072 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1080 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1080 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1092 net_1091 VSS VSS nch w=3u l=0.09u
M_156 net_1092 net_1091 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1095 C VSS nch w=20u l=0.09u
M_158 VSS net_1096 net_1095 VSS nch w=10u l=0.09u
M_159 VDD net_1095 C VDD pch w=30u l=0.09u
M_160 VDD net_1096 net_1095 VDD pch w=10u l=0.09u
M_161 VSS net_1065 net_1097 VSS nch_25od w=0.6u l=0.5u
M_162 net_1096 net_1097 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1098 net_1088 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1099 net_1093 net_1098 VSS nch_25od w=10u l=0.5u
M_165 net_1047 net_1093 net_1087 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1065 net_1096 VSS nch_25od w=5u l=0.5u
M_167 net_1067 net_1093 net_1061 VSS nch_25od w=30u l=0.5u
M_168 net_1100 net_1093 net_1099 VSS nch_25od w=10u l=0.5u
M_169 net_1061 net_1070 net_1100 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1065 net_1097 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1099 net_1093 net_1067 net_1046 pch_25od w=26u l=0.415u
M_172 net_1047 net_1099 net_1087 net_1046 pch_25od w=26u l=0.415u
M_173 VDD net_1065 net_1096 VDD pch_25od w=5u l=0.415u
M_174 net_1046 net_1099 VDDPST net_1046 pch_25od w=24u l=0.415u
M_175 net_1046 net_1093 net_1067 net_1046 pch_25od w=24u l=0.415u
M_176 net_1047 net_1093 net_1067 net_1046 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD04DGZ
.SUBCKT PDD04SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1102 net_1102 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1102 net_1102 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1101 net_1101 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_14 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_15 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_16 net_1104 net_1104 rppolywo w=0.4u l=1.3u m=1
X_17 net_1104 net_1104 rppolywo w=0.4u l=1.3u m=1
X_18 net_1104 net_1104 rppolywo w=0.4u l=1.3u m=1
X_19 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_20 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_21 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_22 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_23 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_24 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_25 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_26 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_27 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
X_28 net_1103 net_1103 rppolywo w=0.4u l=1.3u m=1
M_29 net_1105 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1106 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1107 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1108 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1109 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1110 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1111 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1112 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1113 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1114 net_1101 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_1115 net_1105 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1115 net_1106 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1115 net_1107 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1115 net_1108 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1115 net_1109 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1115 net_1110 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1115 net_1111 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1115 net_1112 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1115 net_1113 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1115 net_1114 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1115 net_1116 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1115 net_1117 VSS nch_25od w=33u l=0.5u
M_51 net_1116 net_1102 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1117 net_1102 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_54 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_55 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_56 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_57 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_58 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_59 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_60 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_61 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_62 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_63 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_64 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_65 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_66 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_67 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_68 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_69 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_70 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_71 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_72 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_73 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_74 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_75 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_76 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_77 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_78 PAD net_1103 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_79 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_80 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_81 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_82 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_83 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_84 PAD net_1104 VDDPST net_1103 pch_25od w=16.5u l=0.415u
M_85 net_1118 net_1119 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1103 net_1103 net_1103 net_1103 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1120 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1121 net_1122 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1121 net_1118 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1122 net_1118 net_1121 VSS nch_25od w=5u l=0.5u
M_91 net_1123 net_1122 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1122 net_1118 net_1123 VDDPST pch_25od w=5u l=0.415u
M_93 net_1123 net_1124 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1125 net_1126 net_1102 VDDPST pch_25od w=20u l=0.415u
M_95 net_1125 net_1127 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1102 net_1127 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1126 net_1102 VSS nch_25od w=15u l=0.5u
M_98 net_1128 net_1129 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1130 net_1131 net_1132 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1133 VSS nch_25od w=10u l=0.5u
M_101 net_1134 net_1131 net_1135 VSS nch_25od w=10u l=0.5u
M_102 net_1133 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1133 net_1128 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1133 net_1128 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1135 VSS nch w=10u l=0.09u
M_106 net_1130 net_1129 VSS VSS nch w=10u l=0.09u
M_107 net_1134 I net_1133 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1128 net_1129 net_1132 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1136 net_1137 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1138 net_1131 net_1139 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1140 VSS nch_25od w=10u l=0.5u
M_112 net_1141 net_1131 net_1142 VSS nch_25od w=10u l=0.5u
M_113 net_1140 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1140 net_1136 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1140 net_1136 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1142 VSS nch w=10u l=0.09u
M_117 net_1138 net_1137 VSS VSS nch w=10u l=0.09u
M_118 net_1141 OEN net_1140 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1136 net_1137 net_1139 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1143 net_1144 VDDPST pch_25od w=40u l=0.415u
M_121 net_1144 net_1145 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1146 net_1143 net_1144 VSS nch_25od w=20u l=0.5u
M_123 net_1146 net_1145 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1147 net_1148 VSS nch w=3u l=0.1u
M_125 net_1147 net_1148 VDD VDD pch w=4u l=0.1u
M_126 net_1148 net_1147 net_1147 VDD pch w=4u l=0.1u
M_127 net_1119 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1120 net_1149 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1119 net_1148 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1119 net_1120 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1120 net_1119 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1131 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1131 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1124 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1101 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1150 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1115 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1148 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1151 net_1128 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1151 net_1128 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1145 net_1136 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1145 net_1136 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1126 net_1133 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1126 net_1133 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1143 net_1151 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1143 net_1151 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1127 net_1140 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1127 net_1140 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1129 I VSS VSS nch w=3u l=0.09u
M_152 net_1129 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1137 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1137 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1149 net_1148 VSS VSS nch w=3u l=0.09u
M_156 net_1149 net_1148 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1152 C VSS nch w=20u l=0.09u
M_158 VSS net_1153 net_1152 VSS nch w=10u l=0.09u
M_159 VDD net_1152 C VDD pch w=30u l=0.09u
M_160 VDD net_1153 net_1152 VDD pch w=10u l=0.09u
M_161 VSS net_1122 net_1154 VSS nch_25od w=0.6u l=0.5u
M_162 net_1153 net_1154 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1155 net_1145 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1156 net_1150 net_1155 VSS nch_25od w=10u l=0.5u
M_165 net_1104 net_1150 net_1144 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1122 net_1153 VSS nch_25od w=5u l=0.5u
M_167 net_1124 net_1150 net_1118 VSS nch_25od w=30u l=0.5u
M_168 net_1157 net_1150 net_1156 VSS nch_25od w=10u l=0.5u
M_169 net_1118 net_1127 net_1157 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1122 net_1154 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1156 net_1150 net_1124 net_1103 pch_25od w=26u l=0.415u
M_172 net_1104 net_1156 net_1144 net_1103 pch_25od w=26u l=0.415u
M_173 VDD net_1122 net_1153 VDD pch_25od w=5u l=0.415u
M_174 net_1103 net_1156 VDDPST net_1103 pch_25od w=24u l=0.415u
M_175 net_1103 net_1150 net_1124 net_1103 pch_25od w=24u l=0.415u
M_176 net_1104 net_1150 net_1124 net_1103 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD04SDGZ
.SUBCKT PDD08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1159 net_1159 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1159 net_1159 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1159 net_1159 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1159 net_1159 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1158 net_1158 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_14 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_15 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_16 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_17 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_18 net_1160 net_1160 rppolywo w=0.4u l=1.3u m=1
X_19 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_20 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_21 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_22 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_23 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_24 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_25 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_26 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_27 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
X_28 net_1161 net_1161 rppolywo w=0.4u l=1.3u m=1
M_29 net_1162 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1163 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1164 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1165 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1166 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1167 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1168 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1169 net_1158 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_1170 net_1162 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1170 net_1163 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1170 net_1164 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1170 net_1165 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1170 net_1166 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1170 net_1167 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1170 net_1168 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1170 net_1169 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1170 net_1171 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1170 net_1172 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1170 net_1173 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1170 net_1174 VSS nch_25od w=33u l=0.5u
M_49 net_1171 net_1159 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1172 net_1159 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1173 net_1159 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1174 net_1159 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_54 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_55 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_56 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_57 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_58 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_59 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_60 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_61 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_62 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_63 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_64 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_65 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_66 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_67 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_68 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_69 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_70 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_71 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_72 PAD net_1161 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_73 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_74 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_75 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_76 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_77 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_78 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_79 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_80 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_81 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_82 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_83 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_84 PAD net_1160 VDDPST net_1161 pch_25od w=16.5u l=0.415u
M_85 net_1175 net_1176 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1161 net_1161 net_1161 net_1161 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1177 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1178 net_1175 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1179 net_1175 net_1178 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1179 net_1175 net_1180 VDDPST pch_25od w=5u l=0.415u
M_93 net_1180 net_1181 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1182 net_1183 net_1159 VDDPST pch_25od w=20u l=0.415u
M_95 net_1182 net_1184 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1159 net_1184 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1183 net_1159 VSS nch_25od w=15u l=0.5u
M_98 net_1185 net_1186 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1187 net_1188 net_1189 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1190 VSS nch_25od w=10u l=0.5u
M_101 net_1191 net_1188 net_1192 VSS nch_25od w=10u l=0.5u
M_102 net_1190 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1190 net_1185 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1190 net_1185 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1192 VSS nch w=10u l=0.09u
M_106 net_1187 net_1186 VSS VSS nch w=10u l=0.09u
M_107 net_1191 I net_1190 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1185 net_1186 net_1189 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1193 net_1194 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1195 net_1188 net_1196 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1197 VSS nch_25od w=10u l=0.5u
M_112 net_1198 net_1188 net_1199 VSS nch_25od w=10u l=0.5u
M_113 net_1197 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1197 net_1193 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1197 net_1193 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1199 VSS nch w=10u l=0.09u
M_117 net_1195 net_1194 VSS VSS nch w=10u l=0.09u
M_118 net_1198 OEN net_1197 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1193 net_1194 net_1196 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1200 net_1201 VDDPST pch_25od w=40u l=0.415u
M_121 net_1201 net_1202 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1203 net_1200 net_1201 VSS nch_25od w=20u l=0.5u
M_123 net_1203 net_1202 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1204 net_1205 VSS nch w=3u l=0.1u
M_125 net_1204 net_1205 VDD VDD pch w=4u l=0.1u
M_126 net_1205 net_1204 net_1204 VDD pch w=4u l=0.1u
M_127 net_1176 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1177 net_1206 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1176 net_1205 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1176 net_1177 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1177 net_1176 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1188 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1188 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1181 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1158 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1207 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1170 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1205 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1208 net_1185 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1208 net_1185 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1202 net_1193 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1202 net_1193 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1183 net_1190 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1183 net_1190 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1200 net_1208 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1200 net_1208 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1184 net_1197 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1184 net_1197 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1186 I VSS VSS nch w=3u l=0.09u
M_152 net_1186 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1194 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1194 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1206 net_1205 VSS VSS nch w=3u l=0.09u
M_156 net_1206 net_1205 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1209 C VSS nch w=20u l=0.09u
M_158 VSS net_1210 net_1209 VSS nch w=10u l=0.09u
M_159 VDD net_1209 C VDD pch w=30u l=0.09u
M_160 VDD net_1210 net_1209 VDD pch w=10u l=0.09u
M_161 VSS net_1179 net_1211 VSS nch_25od w=0.6u l=0.5u
M_162 net_1210 net_1211 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1212 net_1202 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1213 net_1207 net_1212 VSS nch_25od w=10u l=0.5u
M_165 net_1160 net_1207 net_1201 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1179 net_1210 VSS nch_25od w=5u l=0.5u
M_167 net_1181 net_1207 net_1175 VSS nch_25od w=30u l=0.5u
M_168 net_1214 net_1207 net_1213 VSS nch_25od w=10u l=0.5u
M_169 net_1175 net_1184 net_1214 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1179 net_1211 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1213 net_1207 net_1181 net_1161 pch_25od w=26u l=0.415u
M_172 net_1160 net_1213 net_1201 net_1161 pch_25od w=26u l=0.415u
M_173 VDD net_1179 net_1210 VDD pch_25od w=5u l=0.415u
M_174 net_1161 net_1213 VDDPST net_1161 pch_25od w=24u l=0.415u
M_175 net_1161 net_1207 net_1181 net_1161 pch_25od w=24u l=0.415u
M_176 net_1160 net_1207 net_1181 net_1161 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD08DGZ
.SUBCKT PDD08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1216 net_1216 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1216 net_1216 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1216 net_1216 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1216 net_1216 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1215 net_1215 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_14 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_15 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_16 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_17 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_18 net_1217 net_1217 rppolywo w=0.4u l=1.3u m=1
X_19 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_20 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_21 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_22 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_23 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_24 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_25 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_26 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_27 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
X_28 net_1218 net_1218 rppolywo w=0.4u l=1.3u m=1
M_29 net_1219 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1220 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1221 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1222 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1223 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1224 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1225 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1226 net_1215 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_1227 net_1219 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1227 net_1220 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1227 net_1221 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1227 net_1222 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1227 net_1223 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1227 net_1224 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1227 net_1225 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1227 net_1226 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1227 net_1228 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1227 net_1229 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1227 net_1230 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1227 net_1231 VSS nch_25od w=33u l=0.5u
M_49 net_1228 net_1216 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1229 net_1216 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1230 net_1216 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1231 net_1216 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_54 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_55 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_56 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_57 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_58 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_59 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_60 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_61 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_62 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_63 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_64 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_65 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_66 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_67 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_68 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_69 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_70 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_71 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_72 PAD net_1218 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_73 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_74 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_75 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_76 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_77 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_78 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_79 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_80 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_81 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_82 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_83 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_84 PAD net_1217 VDDPST net_1218 pch_25od w=16.5u l=0.415u
M_85 net_1232 net_1233 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1218 net_1218 net_1218 net_1218 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1234 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1235 net_1236 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1235 net_1232 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1236 net_1232 net_1235 VSS nch_25od w=5u l=0.5u
M_91 net_1237 net_1236 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1236 net_1232 net_1237 VDDPST pch_25od w=5u l=0.415u
M_93 net_1237 net_1238 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1239 net_1240 net_1216 VDDPST pch_25od w=20u l=0.415u
M_95 net_1239 net_1241 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1216 net_1241 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1240 net_1216 VSS nch_25od w=15u l=0.5u
M_98 net_1242 net_1243 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1244 net_1245 net_1246 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1247 VSS nch_25od w=10u l=0.5u
M_101 net_1248 net_1245 net_1249 VSS nch_25od w=10u l=0.5u
M_102 net_1247 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1247 net_1242 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1247 net_1242 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1249 VSS nch w=10u l=0.09u
M_106 net_1244 net_1243 VSS VSS nch w=10u l=0.09u
M_107 net_1248 I net_1247 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1242 net_1243 net_1246 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1250 net_1251 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1252 net_1245 net_1253 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1254 VSS nch_25od w=10u l=0.5u
M_112 net_1255 net_1245 net_1256 VSS nch_25od w=10u l=0.5u
M_113 net_1254 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1254 net_1250 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1254 net_1250 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1256 VSS nch w=10u l=0.09u
M_117 net_1252 net_1251 VSS VSS nch w=10u l=0.09u
M_118 net_1255 OEN net_1254 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1250 net_1251 net_1253 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1257 net_1258 VDDPST pch_25od w=40u l=0.415u
M_121 net_1258 net_1259 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1260 net_1257 net_1258 VSS nch_25od w=20u l=0.5u
M_123 net_1260 net_1259 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1261 net_1262 VSS nch w=3u l=0.1u
M_125 net_1261 net_1262 VDD VDD pch w=4u l=0.1u
M_126 net_1262 net_1261 net_1261 VDD pch w=4u l=0.1u
M_127 net_1233 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1234 net_1263 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1233 net_1262 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1233 net_1234 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1234 net_1233 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1245 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1245 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1238 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1215 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1264 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1227 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1262 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1265 net_1242 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1265 net_1242 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1259 net_1250 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1259 net_1250 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1240 net_1247 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1240 net_1247 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1257 net_1265 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1257 net_1265 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1241 net_1254 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1241 net_1254 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1243 I VSS VSS nch w=3u l=0.09u
M_152 net_1243 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1251 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1251 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1263 net_1262 VSS VSS nch w=3u l=0.09u
M_156 net_1263 net_1262 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1266 C VSS nch w=20u l=0.09u
M_158 VSS net_1267 net_1266 VSS nch w=10u l=0.09u
M_159 VDD net_1266 C VDD pch w=30u l=0.09u
M_160 VDD net_1267 net_1266 VDD pch w=10u l=0.09u
M_161 VSS net_1236 net_1268 VSS nch_25od w=0.6u l=0.5u
M_162 net_1267 net_1268 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1269 net_1259 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1270 net_1264 net_1269 VSS nch_25od w=10u l=0.5u
M_165 net_1217 net_1264 net_1258 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1236 net_1267 VSS nch_25od w=5u l=0.5u
M_167 net_1238 net_1264 net_1232 VSS nch_25od w=30u l=0.5u
M_168 net_1271 net_1264 net_1270 VSS nch_25od w=10u l=0.5u
M_169 net_1232 net_1241 net_1271 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1236 net_1268 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1270 net_1264 net_1238 net_1218 pch_25od w=26u l=0.415u
M_172 net_1217 net_1270 net_1258 net_1218 pch_25od w=26u l=0.415u
M_173 VDD net_1236 net_1267 VDD pch_25od w=5u l=0.415u
M_174 net_1218 net_1270 VDDPST net_1218 pch_25od w=24u l=0.415u
M_175 net_1218 net_1264 net_1238 net_1218 pch_25od w=24u l=0.415u
M_176 net_1217 net_1264 net_1238 net_1218 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD08SDGZ
.SUBCKT PDD12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1272 net_1272 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1273 net_1273 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_14 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_15 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_16 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_17 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_18 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_19 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_20 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_21 net_1274 net_1274 rppolywo w=0.4u l=1.3u m=1
X_22 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_23 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_24 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_25 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_26 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_27 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
X_28 net_1275 net_1275 rppolywo w=0.4u l=1.3u m=1
M_29 net_1276 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1277 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1278 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1279 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1280 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1281 net_1273 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_1282 net_1276 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1282 net_1277 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1282 net_1278 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1282 net_1279 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1282 net_1280 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1282 net_1281 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1282 net_1283 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1282 net_1284 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1282 net_1285 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1282 net_1286 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1282 net_1287 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1282 net_1288 VSS nch_25od w=33u l=0.5u
M_47 net_1283 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1284 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1285 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1286 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1287 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1288 net_1272 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_54 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_55 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_56 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_57 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_58 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_59 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_60 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_61 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_62 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_63 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_64 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_65 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_66 PAD net_1275 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_67 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_68 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_69 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_70 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_71 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_72 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_73 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_74 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_75 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_76 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_77 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_78 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_79 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_80 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_81 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_82 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_83 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_84 PAD net_1274 VDDPST net_1275 pch_25od w=16.5u l=0.415u
M_85 net_1289 net_1290 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1275 net_1275 net_1275 net_1275 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1291 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1292 net_1289 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1293 net_1289 net_1292 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1293 net_1289 net_1294 VDDPST pch_25od w=5u l=0.415u
M_93 net_1294 net_1295 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1296 net_1297 net_1272 VDDPST pch_25od w=20u l=0.415u
M_95 net_1296 net_1298 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1272 net_1298 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1297 net_1272 VSS nch_25od w=15u l=0.5u
M_98 net_1299 net_1300 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1301 net_1302 net_1303 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1304 VSS nch_25od w=10u l=0.5u
M_101 net_1305 net_1302 net_1306 VSS nch_25od w=10u l=0.5u
M_102 net_1304 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1304 net_1299 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1304 net_1299 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1306 VSS nch w=10u l=0.09u
M_106 net_1301 net_1300 VSS VSS nch w=10u l=0.09u
M_107 net_1305 I net_1304 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1299 net_1300 net_1303 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1307 net_1308 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1309 net_1302 net_1310 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1311 VSS nch_25od w=10u l=0.5u
M_112 net_1312 net_1302 net_1313 VSS nch_25od w=10u l=0.5u
M_113 net_1311 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1311 net_1307 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1311 net_1307 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1313 VSS nch w=10u l=0.09u
M_117 net_1309 net_1308 VSS VSS nch w=10u l=0.09u
M_118 net_1312 OEN net_1311 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1307 net_1308 net_1310 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1314 net_1315 VDDPST pch_25od w=40u l=0.415u
M_121 net_1315 net_1316 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1317 net_1314 net_1315 VSS nch_25od w=20u l=0.5u
M_123 net_1317 net_1316 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1318 net_1319 VSS nch w=3u l=0.1u
M_125 net_1318 net_1319 VDD VDD pch w=4u l=0.1u
M_126 net_1319 net_1318 net_1318 VDD pch w=4u l=0.1u
M_127 net_1290 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1291 net_1320 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1290 net_1319 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1290 net_1291 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1291 net_1290 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1302 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1302 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1295 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1273 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1321 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1282 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1319 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1322 net_1299 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1322 net_1299 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1316 net_1307 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1316 net_1307 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1297 net_1304 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1297 net_1304 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1314 net_1322 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1314 net_1322 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1298 net_1311 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1298 net_1311 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1300 I VSS VSS nch w=3u l=0.09u
M_152 net_1300 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1308 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1308 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1320 net_1319 VSS VSS nch w=3u l=0.09u
M_156 net_1320 net_1319 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1323 C VSS nch w=20u l=0.09u
M_158 VSS net_1324 net_1323 VSS nch w=10u l=0.09u
M_159 VDD net_1323 C VDD pch w=30u l=0.09u
M_160 VDD net_1324 net_1323 VDD pch w=10u l=0.09u
M_161 VSS net_1293 net_1325 VSS nch_25od w=0.6u l=0.5u
M_162 net_1324 net_1325 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1326 net_1316 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1327 net_1321 net_1326 VSS nch_25od w=10u l=0.5u
M_165 net_1274 net_1321 net_1315 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1293 net_1324 VSS nch_25od w=5u l=0.5u
M_167 net_1295 net_1321 net_1289 VSS nch_25od w=30u l=0.5u
M_168 net_1328 net_1321 net_1327 VSS nch_25od w=10u l=0.5u
M_169 net_1289 net_1298 net_1328 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1293 net_1325 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1327 net_1321 net_1295 net_1275 pch_25od w=26u l=0.415u
M_172 net_1274 net_1327 net_1315 net_1275 pch_25od w=26u l=0.415u
M_173 VDD net_1293 net_1324 VDD pch_25od w=5u l=0.415u
M_174 net_1275 net_1327 VDDPST net_1275 pch_25od w=24u l=0.415u
M_175 net_1275 net_1321 net_1295 net_1275 pch_25od w=24u l=0.415u
M_176 net_1274 net_1321 net_1295 net_1275 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD12DGZ
.SUBCKT PDD12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1329 net_1329 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1330 net_1330 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_14 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_15 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_16 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_17 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_18 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_19 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_20 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_21 net_1331 net_1331 rppolywo w=0.4u l=1.3u m=1
X_22 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_23 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_24 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_25 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_26 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_27 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
X_28 net_1332 net_1332 rppolywo w=0.4u l=1.3u m=1
M_29 net_1333 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1334 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1335 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1336 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1337 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1338 net_1330 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_1339 net_1333 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1339 net_1334 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1339 net_1335 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1339 net_1336 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1339 net_1337 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1339 net_1338 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1339 net_1340 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1339 net_1341 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1339 net_1342 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1339 net_1343 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1339 net_1344 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1339 net_1345 VSS nch_25od w=33u l=0.5u
M_47 net_1340 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1341 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1342 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1343 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1344 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1345 net_1329 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_54 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_55 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_56 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_57 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_58 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_59 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_60 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_61 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_62 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_63 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_64 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_65 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_66 PAD net_1332 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_67 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_68 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_69 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_70 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_71 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_72 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_73 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_74 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_75 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_76 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_77 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_78 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_79 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_80 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_81 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_82 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_83 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_84 PAD net_1331 VDDPST net_1332 pch_25od w=16.5u l=0.415u
M_85 net_1346 net_1347 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1332 net_1332 net_1332 net_1332 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1348 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1349 net_1350 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1349 net_1346 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1350 net_1346 net_1349 VSS nch_25od w=5u l=0.5u
M_91 net_1351 net_1350 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1350 net_1346 net_1351 VDDPST pch_25od w=5u l=0.415u
M_93 net_1351 net_1352 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1353 net_1354 net_1329 VDDPST pch_25od w=20u l=0.415u
M_95 net_1353 net_1355 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1329 net_1355 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1354 net_1329 VSS nch_25od w=15u l=0.5u
M_98 net_1356 net_1357 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1358 net_1359 net_1360 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1361 VSS nch_25od w=10u l=0.5u
M_101 net_1362 net_1359 net_1363 VSS nch_25od w=10u l=0.5u
M_102 net_1361 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1361 net_1356 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1361 net_1356 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1363 VSS nch w=10u l=0.09u
M_106 net_1358 net_1357 VSS VSS nch w=10u l=0.09u
M_107 net_1362 I net_1361 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1356 net_1357 net_1360 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1364 net_1365 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1366 net_1359 net_1367 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1368 VSS nch_25od w=10u l=0.5u
M_112 net_1369 net_1359 net_1370 VSS nch_25od w=10u l=0.5u
M_113 net_1368 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1368 net_1364 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1368 net_1364 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1370 VSS nch w=10u l=0.09u
M_117 net_1366 net_1365 VSS VSS nch w=10u l=0.09u
M_118 net_1369 OEN net_1368 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1364 net_1365 net_1367 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1371 net_1372 VDDPST pch_25od w=40u l=0.415u
M_121 net_1372 net_1373 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1374 net_1371 net_1372 VSS nch_25od w=20u l=0.5u
M_123 net_1374 net_1373 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1375 net_1376 VSS nch w=3u l=0.1u
M_125 net_1375 net_1376 VDD VDD pch w=4u l=0.1u
M_126 net_1376 net_1375 net_1375 VDD pch w=4u l=0.1u
M_127 net_1347 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1348 net_1377 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1347 net_1376 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1347 net_1348 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1348 net_1347 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1359 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1359 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1352 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1330 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1378 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1339 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1376 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1379 net_1356 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1379 net_1356 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1373 net_1364 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1373 net_1364 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1354 net_1361 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1354 net_1361 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1371 net_1379 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1371 net_1379 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1355 net_1368 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1355 net_1368 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1357 I VSS VSS nch w=3u l=0.09u
M_152 net_1357 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1365 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1365 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1377 net_1376 VSS VSS nch w=3u l=0.09u
M_156 net_1377 net_1376 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1380 C VSS nch w=20u l=0.09u
M_158 VSS net_1381 net_1380 VSS nch w=10u l=0.09u
M_159 VDD net_1380 C VDD pch w=30u l=0.09u
M_160 VDD net_1381 net_1380 VDD pch w=10u l=0.09u
M_161 VSS net_1350 net_1382 VSS nch_25od w=0.6u l=0.5u
M_162 net_1381 net_1382 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1383 net_1373 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1384 net_1378 net_1383 VSS nch_25od w=10u l=0.5u
M_165 net_1331 net_1378 net_1372 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1350 net_1381 VSS nch_25od w=5u l=0.5u
M_167 net_1352 net_1378 net_1346 VSS nch_25od w=30u l=0.5u
M_168 net_1385 net_1378 net_1384 VSS nch_25od w=10u l=0.5u
M_169 net_1346 net_1355 net_1385 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1350 net_1382 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1384 net_1378 net_1352 net_1332 pch_25od w=26u l=0.415u
M_172 net_1331 net_1384 net_1372 net_1332 pch_25od w=26u l=0.415u
M_173 VDD net_1350 net_1381 VDD pch_25od w=5u l=0.415u
M_174 net_1332 net_1384 VDDPST net_1332 pch_25od w=24u l=0.415u
M_175 net_1332 net_1378 net_1352 net_1332 pch_25od w=24u l=0.415u
M_176 net_1331 net_1378 net_1352 net_1332 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD12SDGZ
.SUBCKT PDD16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1386 net_1386 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1386 net_1386 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1386 net_1386 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1386 net_1386 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1387 net_1387 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_14 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_15 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_16 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_17 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_18 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_19 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_20 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_21 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_22 net_1389 net_1389 rppolywo w=0.4u l=1.3u m=1
X_23 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_24 net_1389 net_1389 rppolywo w=0.4u l=1.3u m=1
X_25 net_1389 net_1389 rppolywo w=0.4u l=1.3u m=1
X_26 net_1389 net_1389 rppolywo w=0.4u l=1.3u m=1
X_27 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
X_28 net_1388 net_1388 rppolywo w=0.4u l=1.3u m=1
M_29 net_1390 net_1386 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1391 net_1386 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1392 net_1386 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1393 net_1386 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_1394 net_1390 VSS nch_25od w=33u l=0.5u
M_34 PAD net_1394 net_1391 VSS nch_25od w=33u l=0.5u
M_35 PAD net_1394 net_1392 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1394 net_1393 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1394 net_1395 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1394 net_1396 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1394 net_1397 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1394 net_1398 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1394 net_1399 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1394 net_1400 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1394 net_1401 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1394 net_1402 VSS nch_25od w=33u l=0.5u
M_45 net_1395 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_46 net_1396 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_47 net_1397 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1398 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1399 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1400 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1401 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1402 net_1387 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_54 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_55 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_56 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_57 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_58 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_59 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_60 PAD net_1389 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_61 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_62 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_63 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_64 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_65 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_66 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_67 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_68 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_69 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_70 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_71 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_72 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_73 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_74 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_75 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_76 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_77 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_78 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_79 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_80 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_81 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_82 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_83 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_84 PAD net_1388 VDDPST net_1389 pch_25od w=16.5u l=0.415u
M_85 net_1403 net_1404 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1389 net_1389 net_1389 net_1389 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1405 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1406 net_1403 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1407 net_1403 net_1406 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1407 net_1403 net_1408 VDDPST pch_25od w=5u l=0.415u
M_93 net_1408 net_1409 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1410 net_1411 net_1387 VDDPST pch_25od w=20u l=0.415u
M_95 net_1410 net_1412 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1387 net_1412 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1411 net_1387 VSS nch_25od w=15u l=0.5u
M_98 net_1413 net_1414 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1415 net_1416 net_1417 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1418 VSS nch_25od w=10u l=0.5u
M_101 net_1419 net_1416 net_1420 VSS nch_25od w=10u l=0.5u
M_102 net_1418 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1418 net_1413 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1418 net_1413 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1420 VSS nch w=10u l=0.09u
M_106 net_1415 net_1414 VSS VSS nch w=10u l=0.09u
M_107 net_1419 I net_1418 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1413 net_1414 net_1417 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1421 net_1422 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1423 net_1416 net_1424 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1425 VSS nch_25od w=10u l=0.5u
M_112 net_1426 net_1416 net_1427 VSS nch_25od w=10u l=0.5u
M_113 net_1425 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1425 net_1421 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1425 net_1421 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1427 VSS nch w=10u l=0.09u
M_117 net_1423 net_1422 VSS VSS nch w=10u l=0.09u
M_118 net_1426 OEN net_1425 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1421 net_1422 net_1424 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1428 net_1429 VDDPST pch_25od w=40u l=0.415u
M_121 net_1429 net_1430 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1431 net_1428 net_1429 VSS nch_25od w=20u l=0.5u
M_123 net_1431 net_1430 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1432 net_1433 VSS nch w=3u l=0.1u
M_125 net_1432 net_1433 VDD VDD pch w=4u l=0.1u
M_126 net_1433 net_1432 net_1432 VDD pch w=4u l=0.1u
M_127 net_1404 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1405 net_1434 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1404 net_1433 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1404 net_1405 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1405 net_1404 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1416 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1416 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1409 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1386 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1435 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1394 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1433 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1436 net_1413 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1436 net_1413 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1430 net_1421 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1430 net_1421 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1411 net_1418 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1411 net_1418 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1428 net_1436 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1428 net_1436 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1412 net_1425 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1412 net_1425 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1414 I VSS VSS nch w=3u l=0.09u
M_152 net_1414 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1422 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1422 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1434 net_1433 VSS VSS nch w=3u l=0.09u
M_156 net_1434 net_1433 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1437 C VSS nch w=20u l=0.09u
M_158 VSS net_1438 net_1437 VSS nch w=10u l=0.09u
M_159 VDD net_1437 C VDD pch w=30u l=0.09u
M_160 VDD net_1438 net_1437 VDD pch w=10u l=0.09u
M_161 VSS net_1407 net_1439 VSS nch_25od w=0.6u l=0.5u
M_162 net_1438 net_1439 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1440 net_1430 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1441 net_1435 net_1440 VSS nch_25od w=10u l=0.5u
M_165 net_1388 net_1435 net_1429 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1407 net_1438 VSS nch_25od w=5u l=0.5u
M_167 net_1409 net_1435 net_1403 VSS nch_25od w=30u l=0.5u
M_168 net_1442 net_1435 net_1441 VSS nch_25od w=10u l=0.5u
M_169 net_1403 net_1412 net_1442 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1407 net_1439 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1441 net_1435 net_1409 net_1389 pch_25od w=26u l=0.415u
M_172 net_1388 net_1441 net_1429 net_1389 pch_25od w=26u l=0.415u
M_173 VDD net_1407 net_1438 VDD pch_25od w=5u l=0.415u
M_174 net_1389 net_1441 VDDPST net_1389 pch_25od w=24u l=0.415u
M_175 net_1389 net_1435 net_1409 net_1389 pch_25od w=24u l=0.415u
M_176 net_1388 net_1435 net_1409 net_1389 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD16DGZ
.SUBCKT PDD16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1443 net_1443 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1443 net_1443 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1443 net_1443 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1443 net_1443 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1444 net_1444 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_14 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_15 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_16 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_17 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_18 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_19 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_20 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_21 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_22 net_1446 net_1446 rppolywo w=0.4u l=1.3u m=1
X_23 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_24 net_1446 net_1446 rppolywo w=0.4u l=1.3u m=1
X_25 net_1446 net_1446 rppolywo w=0.4u l=1.3u m=1
X_26 net_1446 net_1446 rppolywo w=0.4u l=1.3u m=1
X_27 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
X_28 net_1445 net_1445 rppolywo w=0.4u l=1.3u m=1
M_29 net_1447 net_1443 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1448 net_1443 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1449 net_1443 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1450 net_1443 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_1451 net_1447 VSS nch_25od w=33u l=0.5u
M_34 PAD net_1451 net_1448 VSS nch_25od w=33u l=0.5u
M_35 PAD net_1451 net_1449 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1451 net_1450 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1451 net_1452 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1451 net_1453 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1451 net_1454 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1451 net_1455 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1451 net_1456 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1451 net_1457 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1451 net_1458 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1451 net_1459 VSS nch_25od w=33u l=0.5u
M_45 net_1452 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_46 net_1453 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_47 net_1454 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1455 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1456 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1457 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1458 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1459 net_1444 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_54 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_55 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_56 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_57 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_58 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_59 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_60 PAD net_1446 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_61 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_62 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_63 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_64 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_65 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_66 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_67 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_68 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_69 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_70 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_71 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_72 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_73 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_74 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_75 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_76 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_77 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_78 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_79 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_80 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_81 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_82 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_83 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_84 PAD net_1445 VDDPST net_1446 pch_25od w=16.5u l=0.415u
M_85 net_1460 net_1461 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1446 net_1446 net_1446 net_1446 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1462 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1463 net_1464 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1463 net_1460 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1464 net_1460 net_1463 VSS nch_25od w=5u l=0.5u
M_91 net_1465 net_1464 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1464 net_1460 net_1465 VDDPST pch_25od w=5u l=0.415u
M_93 net_1465 net_1466 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1467 net_1468 net_1444 VDDPST pch_25od w=20u l=0.415u
M_95 net_1467 net_1469 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1444 net_1469 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1468 net_1444 VSS nch_25od w=15u l=0.5u
M_98 net_1470 net_1471 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1472 net_1473 net_1474 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1475 VSS nch_25od w=10u l=0.5u
M_101 net_1476 net_1473 net_1477 VSS nch_25od w=10u l=0.5u
M_102 net_1475 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1475 net_1470 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1475 net_1470 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1477 VSS nch w=10u l=0.09u
M_106 net_1472 net_1471 VSS VSS nch w=10u l=0.09u
M_107 net_1476 I net_1475 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1470 net_1471 net_1474 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1478 net_1479 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1480 net_1473 net_1481 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1482 VSS nch_25od w=10u l=0.5u
M_112 net_1483 net_1473 net_1484 VSS nch_25od w=10u l=0.5u
M_113 net_1482 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1482 net_1478 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1482 net_1478 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1484 VSS nch w=10u l=0.09u
M_117 net_1480 net_1479 VSS VSS nch w=10u l=0.09u
M_118 net_1483 OEN net_1482 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1478 net_1479 net_1481 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1485 net_1486 VDDPST pch_25od w=40u l=0.415u
M_121 net_1486 net_1487 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1488 net_1485 net_1486 VSS nch_25od w=20u l=0.5u
M_123 net_1488 net_1487 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1489 net_1490 VSS nch w=3u l=0.1u
M_125 net_1489 net_1490 VDD VDD pch w=4u l=0.1u
M_126 net_1490 net_1489 net_1489 VDD pch w=4u l=0.1u
M_127 net_1461 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1462 net_1491 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1461 net_1490 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1461 net_1462 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1462 net_1461 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1473 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1473 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1466 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1443 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1492 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1451 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1490 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1493 net_1470 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1493 net_1470 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1487 net_1478 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1487 net_1478 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1468 net_1475 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1468 net_1475 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1485 net_1493 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1485 net_1493 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1469 net_1482 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1469 net_1482 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1471 I VSS VSS nch w=3u l=0.09u
M_152 net_1471 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1479 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1479 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1491 net_1490 VSS VSS nch w=3u l=0.09u
M_156 net_1491 net_1490 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1494 C VSS nch w=20u l=0.09u
M_158 VSS net_1495 net_1494 VSS nch w=10u l=0.09u
M_159 VDD net_1494 C VDD pch w=30u l=0.09u
M_160 VDD net_1495 net_1494 VDD pch w=10u l=0.09u
M_161 VSS net_1464 net_1496 VSS nch_25od w=0.6u l=0.5u
M_162 net_1495 net_1496 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1497 net_1487 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1498 net_1492 net_1497 VSS nch_25od w=10u l=0.5u
M_165 net_1445 net_1492 net_1486 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1464 net_1495 VSS nch_25od w=5u l=0.5u
M_167 net_1466 net_1492 net_1460 VSS nch_25od w=30u l=0.5u
M_168 net_1499 net_1492 net_1498 VSS nch_25od w=10u l=0.5u
M_169 net_1460 net_1469 net_1499 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1464 net_1496 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1498 net_1492 net_1466 net_1446 pch_25od w=26u l=0.415u
M_172 net_1445 net_1498 net_1486 net_1446 pch_25od w=26u l=0.415u
M_173 VDD net_1464 net_1495 VDD pch_25od w=5u l=0.415u
M_174 net_1446 net_1498 VDDPST net_1446 pch_25od w=24u l=0.415u
M_175 net_1446 net_1492 net_1466 net_1446 pch_25od w=24u l=0.415u
M_176 net_1445 net_1492 net_1466 net_1446 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD16SDGZ
.SUBCKT PDD24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1500 net_1500 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_14 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_15 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_16 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_17 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_18 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_19 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_20 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_21 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_22 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_23 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_24 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_25 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_26 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_27 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
X_28 net_1501 net_1501 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_1502 net_1503 VSS nch_25od w=33u l=0.5u
M_30 PAD net_1502 net_1504 VSS nch_25od w=33u l=0.5u
M_31 PAD net_1502 net_1505 VSS nch_25od w=33u l=0.5u
M_32 PAD net_1502 net_1506 VSS nch_25od w=33u l=0.5u
M_33 PAD net_1502 net_1507 VSS nch_25od w=33u l=0.5u
M_34 PAD net_1502 net_1508 VSS nch_25od w=33u l=0.5u
M_35 PAD net_1502 net_1509 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1502 net_1510 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1502 net_1511 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1502 net_1512 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1502 net_1513 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1502 net_1514 VSS nch_25od w=33u l=0.5u
M_41 net_1503 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_42 net_1504 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_43 net_1505 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_44 net_1506 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_45 net_1507 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_46 net_1508 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_47 net_1509 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1510 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1511 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1512 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1513 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1514 net_1500 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_54 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_55 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_56 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_57 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_58 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_59 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_60 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_61 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_62 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_63 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_64 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_65 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_66 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_67 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_68 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_69 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_70 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_71 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_72 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_73 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_74 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_75 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_76 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_77 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_78 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_79 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_80 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_81 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_82 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_83 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_84 PAD net_1501 VDDPST net_1515 pch_25od w=16.5u l=0.415u
M_85 net_1516 net_1517 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1515 net_1515 net_1515 net_1515 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1518 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1519 net_1516 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1520 net_1516 net_1519 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1520 net_1516 net_1521 VDDPST pch_25od w=5u l=0.415u
M_93 net_1521 net_1522 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1523 net_1524 net_1500 VDDPST pch_25od w=20u l=0.415u
M_95 net_1523 net_1525 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1500 net_1525 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1524 net_1500 VSS nch_25od w=15u l=0.5u
M_98 net_1526 net_1527 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1528 net_1529 net_1530 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1531 VSS nch_25od w=10u l=0.5u
M_101 net_1532 net_1529 net_1533 VSS nch_25od w=10u l=0.5u
M_102 net_1531 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1531 net_1526 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1531 net_1526 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1533 VSS nch w=10u l=0.09u
M_106 net_1528 net_1527 VSS VSS nch w=10u l=0.09u
M_107 net_1532 I net_1531 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1526 net_1527 net_1530 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1534 net_1535 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1536 net_1529 net_1537 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1538 VSS nch_25od w=10u l=0.5u
M_112 net_1539 net_1529 net_1540 VSS nch_25od w=10u l=0.5u
M_113 net_1538 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1538 net_1534 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1538 net_1534 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1540 VSS nch w=10u l=0.09u
M_117 net_1536 net_1535 VSS VSS nch w=10u l=0.09u
M_118 net_1539 OEN net_1538 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1534 net_1535 net_1537 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1541 net_1542 VDDPST pch_25od w=40u l=0.415u
M_121 net_1542 net_1543 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1544 net_1541 net_1542 VSS nch_25od w=20u l=0.5u
M_123 net_1544 net_1543 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1545 net_1546 VSS nch w=3u l=0.1u
M_125 net_1545 net_1546 VDD VDD pch w=4u l=0.1u
M_126 net_1546 net_1545 net_1545 VDD pch w=4u l=0.1u
M_127 net_1517 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1518 net_1547 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1517 net_1546 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1517 net_1518 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1518 net_1517 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1529 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1529 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1522 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1548 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1549 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1502 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1546 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1550 net_1526 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1550 net_1526 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1543 net_1534 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1543 net_1534 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1524 net_1531 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1524 net_1531 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1541 net_1550 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1541 net_1550 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1525 net_1538 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1525 net_1538 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1527 I VSS VSS nch w=3u l=0.09u
M_152 net_1527 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1535 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1535 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1547 net_1546 VSS VSS nch w=3u l=0.09u
M_156 net_1547 net_1546 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1551 C VSS nch w=20u l=0.09u
M_158 VSS net_1552 net_1551 VSS nch w=10u l=0.09u
M_159 VDD net_1551 C VDD pch w=30u l=0.09u
M_160 VDD net_1552 net_1551 VDD pch w=10u l=0.09u
M_161 VSS net_1520 net_1553 VSS nch_25od w=0.6u l=0.5u
M_162 net_1552 net_1553 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1554 net_1543 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1555 net_1549 net_1554 VSS nch_25od w=10u l=0.5u
M_165 net_1501 net_1549 net_1542 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1520 net_1552 VSS nch_25od w=5u l=0.5u
M_167 net_1522 net_1549 net_1516 VSS nch_25od w=30u l=0.5u
M_168 net_1556 net_1549 net_1555 VSS nch_25od w=10u l=0.5u
M_169 net_1516 net_1525 net_1556 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1520 net_1553 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1555 net_1549 net_1522 net_1515 pch_25od w=26u l=0.415u
M_172 net_1501 net_1555 net_1542 net_1515 pch_25od w=26u l=0.415u
M_173 VDD net_1520 net_1552 VDD pch_25od w=5u l=0.415u
M_174 net_1515 net_1555 VDDPST net_1515 pch_25od w=24u l=0.415u
M_175 net_1515 net_1549 net_1522 net_1515 pch_25od w=24u l=0.415u
M_176 net_1501 net_1549 net_1522 net_1515 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD24DGZ
.SUBCKT PDD24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1557 net_1557 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_14 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_15 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_16 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_17 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_18 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_19 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_20 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_21 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_22 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_23 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_24 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_25 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_26 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_27 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
X_28 net_1558 net_1558 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_1559 net_1560 VSS nch_25od w=33u l=0.5u
M_30 PAD net_1559 net_1561 VSS nch_25od w=33u l=0.5u
M_31 PAD net_1559 net_1562 VSS nch_25od w=33u l=0.5u
M_32 PAD net_1559 net_1563 VSS nch_25od w=33u l=0.5u
M_33 PAD net_1559 net_1564 VSS nch_25od w=33u l=0.5u
M_34 PAD net_1559 net_1565 VSS nch_25od w=33u l=0.5u
M_35 PAD net_1559 net_1566 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1559 net_1567 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1559 net_1568 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1559 net_1569 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1559 net_1570 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1559 net_1571 VSS nch_25od w=33u l=0.5u
M_41 net_1560 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_42 net_1561 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_43 net_1562 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_44 net_1563 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_45 net_1564 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_46 net_1565 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_47 net_1566 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1567 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1568 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1569 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1570 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1571 net_1557 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_54 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_55 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_56 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_57 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_58 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_59 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_60 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_61 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_62 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_63 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_64 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_65 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_66 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_67 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_68 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_69 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_70 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_71 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_72 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_73 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_74 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_75 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_76 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_77 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_78 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_79 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_80 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_81 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_82 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_83 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_84 PAD net_1558 VDDPST net_1572 pch_25od w=16.5u l=0.415u
M_85 net_1573 net_1574 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1572 net_1572 net_1572 net_1572 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1575 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1576 net_1577 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1576 net_1573 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1577 net_1573 net_1576 VSS nch_25od w=5u l=0.5u
M_91 net_1578 net_1577 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1577 net_1573 net_1578 VDDPST pch_25od w=5u l=0.415u
M_93 net_1578 net_1579 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1580 net_1581 net_1557 VDDPST pch_25od w=20u l=0.415u
M_95 net_1580 net_1582 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1557 net_1582 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1581 net_1557 VSS nch_25od w=15u l=0.5u
M_98 net_1583 net_1584 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1585 net_1586 net_1587 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1588 VSS nch_25od w=10u l=0.5u
M_101 net_1589 net_1586 net_1590 VSS nch_25od w=10u l=0.5u
M_102 net_1588 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1588 net_1583 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1588 net_1583 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1590 VSS nch w=10u l=0.09u
M_106 net_1585 net_1584 VSS VSS nch w=10u l=0.09u
M_107 net_1589 I net_1588 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1583 net_1584 net_1587 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1591 net_1592 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1593 net_1586 net_1594 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1595 VSS nch_25od w=10u l=0.5u
M_112 net_1596 net_1586 net_1597 VSS nch_25od w=10u l=0.5u
M_113 net_1595 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1595 net_1591 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1595 net_1591 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1597 VSS nch w=10u l=0.09u
M_117 net_1593 net_1592 VSS VSS nch w=10u l=0.09u
M_118 net_1596 OEN net_1595 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1591 net_1592 net_1594 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1598 net_1599 VDDPST pch_25od w=40u l=0.415u
M_121 net_1599 net_1600 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1601 net_1598 net_1599 VSS nch_25od w=20u l=0.5u
M_123 net_1601 net_1600 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1602 net_1603 VSS nch w=3u l=0.1u
M_125 net_1602 net_1603 VDD VDD pch w=4u l=0.1u
M_126 net_1603 net_1602 net_1602 VDD pch w=4u l=0.1u
M_127 net_1574 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1575 net_1604 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1574 net_1603 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1574 net_1575 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1575 net_1574 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1586 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1586 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1579 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1605 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1606 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1559 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1603 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1607 net_1583 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1607 net_1583 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1600 net_1591 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1600 net_1591 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1581 net_1588 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1581 net_1588 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1598 net_1607 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1598 net_1607 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1582 net_1595 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1582 net_1595 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1584 I VSS VSS nch w=3u l=0.09u
M_152 net_1584 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1592 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1592 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1604 net_1603 VSS VSS nch w=3u l=0.09u
M_156 net_1604 net_1603 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1608 C VSS nch w=20u l=0.09u
M_158 VSS net_1609 net_1608 VSS nch w=10u l=0.09u
M_159 VDD net_1608 C VDD pch w=30u l=0.09u
M_160 VDD net_1609 net_1608 VDD pch w=10u l=0.09u
M_161 VSS net_1577 net_1610 VSS nch_25od w=0.6u l=0.5u
M_162 net_1609 net_1610 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1611 net_1600 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1612 net_1606 net_1611 VSS nch_25od w=10u l=0.5u
M_165 net_1558 net_1606 net_1599 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1577 net_1609 VSS nch_25od w=5u l=0.5u
M_167 net_1579 net_1606 net_1573 VSS nch_25od w=30u l=0.5u
M_168 net_1613 net_1606 net_1612 VSS nch_25od w=10u l=0.5u
M_169 net_1573 net_1582 net_1613 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1577 net_1610 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1612 net_1606 net_1579 net_1572 pch_25od w=26u l=0.415u
M_172 net_1558 net_1612 net_1599 net_1572 pch_25od w=26u l=0.415u
M_173 VDD net_1577 net_1609 VDD pch_25od w=5u l=0.415u
M_174 net_1572 net_1612 VDDPST net_1572 pch_25od w=24u l=0.415u
M_175 net_1572 net_1606 net_1579 net_1572 pch_25od w=24u l=0.415u
M_176 net_1558 net_1606 net_1579 net_1572 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDD24SDGZ
.SUBCKT PDDDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1614 net_1614 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_14 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_15 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_16 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_17 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_18 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_19 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_20 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_21 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_22 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_23 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_24 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_25 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_26 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_27 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
X_28 net_1615 net_1615 rppolywo w=0.4u l=1.3u m=1
M_29 net_1616 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1617 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1618 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1619 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1620 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1621 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1622 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1623 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1624 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1625 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_39 net_1626 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_40 net_1627 net_1614 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_1628 net_1616 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1628 net_1617 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1628 net_1618 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1628 net_1619 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1628 net_1620 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1628 net_1621 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1628 net_1622 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1628 net_1623 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1628 net_1624 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1628 net_1625 VSS nch_25od w=33u l=0.5u
M_51 PAD net_1628 net_1626 VSS nch_25od w=33u l=0.5u
M_52 PAD net_1628 net_1627 VSS nch_25od w=33u l=0.5u
M_53 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_54 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_55 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_56 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_57 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_58 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_59 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_60 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_61 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_62 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_63 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_64 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_65 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_66 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_67 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_68 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_69 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_70 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_71 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_72 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_73 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_74 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_75 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_76 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_77 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_78 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_79 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_80 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_81 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_82 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_83 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_84 PAD net_1615 VDDPST net_1615 pch_25od w=16.5u l=0.415u
M_85 net_1629 net_1630 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1615 net_1615 net_1615 net_1615 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1631 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1632 net_1629 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1633 net_1629 net_1632 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1633 net_1629 net_1634 VDDPST pch_25od w=5u l=0.415u
M_93 net_1634 net_1635 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1636 net_1637 net_1638 VDDPST pch_25od w=20u l=0.415u
M_95 net_1636 net_1639 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1638 net_1639 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1637 net_1638 VSS nch_25od w=15u l=0.5u
M_98 net_1640 net_1641 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1642 net_1643 net_1644 VSS nch_25od w=10u l=0.5u
M_100 VSS net_1645 net_1646 VSS nch_25od w=10u l=0.5u
M_101 net_1647 net_1643 net_1648 VSS nch_25od w=10u l=0.5u
M_102 net_1646 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1646 net_1640 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1646 net_1640 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_1645 net_1648 VSS nch w=10u l=0.09u
M_106 net_1642 net_1641 VSS VSS nch w=10u l=0.09u
M_107 net_1647 net_1645 net_1646 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1640 net_1641 net_1644 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1649 net_1650 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1651 net_1643 net_1652 VSS nch_25od w=10u l=0.5u
M_111 VSS net_1653 net_1654 VSS nch_25od w=10u l=0.5u
M_112 net_1655 net_1643 net_1656 VSS nch_25od w=10u l=0.5u
M_113 net_1654 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1654 net_1649 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1654 net_1649 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_1653 net_1656 VSS nch w=10u l=0.09u
M_117 net_1651 net_1650 VSS VSS nch w=10u l=0.09u
M_118 net_1655 net_1653 net_1654 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1649 net_1650 net_1652 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1657 net_1658 VDDPST pch_25od w=40u l=0.415u
M_121 net_1658 net_1659 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1660 net_1657 net_1658 VSS nch_25od w=20u l=0.5u
M_123 net_1660 net_1659 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1653 net_1645 VSS nch w=3u l=0.1u
M_125 net_1653 net_1645 VDD VDD pch w=4u l=0.1u
M_126 net_1645 net_1653 net_1653 VDD pch w=4u l=0.1u
M_127 net_1630 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1631 net_1661 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1630 net_1645 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1630 net_1631 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1631 net_1630 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1643 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1643 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1635 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1614 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1662 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1628 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1645 ndio area=4p
D_139 VSS net_1653 ndio area=4p
D_140 VSS net_1645 ndio area=4p
M_141 net_1663 net_1640 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1663 net_1640 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1659 net_1649 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1659 net_1649 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1637 net_1646 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1637 net_1646 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1657 net_1663 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1657 net_1663 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1639 net_1654 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1639 net_1654 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1641 net_1645 VSS VSS nch w=3u l=0.09u
M_152 net_1641 net_1645 VDD VDD pch w=7.5u l=0.09u
M_153 net_1650 net_1653 VSS VSS nch w=3u l=0.09u
M_154 net_1650 net_1653 VDD VDD pch w=7.5u l=0.09u
M_155 net_1661 net_1645 VSS VSS nch w=3u l=0.09u
M_156 net_1661 net_1645 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1664 C VSS nch w=20u l=0.09u
M_158 VSS net_1665 net_1664 VSS nch w=10u l=0.09u
M_159 VDD net_1664 C VDD pch w=30u l=0.09u
M_160 VDD net_1665 net_1664 VDD pch w=10u l=0.09u
M_161 VSS net_1633 net_1666 VSS nch_25od w=0.6u l=0.5u
M_162 net_1665 net_1666 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1667 net_1659 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1668 net_1662 net_1667 VSS nch_25od w=10u l=0.5u
M_165 net_1669 net_1662 net_1658 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1633 net_1665 VSS nch_25od w=5u l=0.5u
M_167 net_1635 net_1662 net_1629 VSS nch_25od w=30u l=0.5u
M_168 net_1670 net_1662 net_1668 VSS nch_25od w=10u l=0.5u
M_169 net_1629 net_1639 net_1670 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1633 net_1666 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1668 net_1662 net_1635 net_1615 pch_25od w=26u l=0.415u
M_172 net_1669 net_1668 net_1658 net_1615 pch_25od w=26u l=0.415u
M_173 VDD net_1633 net_1665 VDD pch_25od w=5u l=0.415u
M_174 net_1615 net_1668 VDDPST net_1615 pch_25od w=24u l=0.415u
M_175 net_1615 net_1662 net_1635 net_1615 pch_25od w=24u l=0.415u
M_176 net_1669 net_1662 net_1635 net_1615 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDDGZ
.SUBCKT PDDSDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1671 net_1671 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_14 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_15 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_16 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_17 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_18 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_19 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_20 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_21 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_22 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_23 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_24 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_25 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_26 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_27 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
X_28 net_1672 net_1672 rppolywo w=0.4u l=1.3u m=1
M_29 net_1673 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1674 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1675 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1676 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1677 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1678 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1679 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1680 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1681 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1682 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_39 net_1683 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_40 net_1684 net_1671 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_1685 net_1673 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1685 net_1674 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1685 net_1675 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1685 net_1676 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1685 net_1677 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1685 net_1678 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1685 net_1679 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1685 net_1680 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1685 net_1681 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1685 net_1682 VSS nch_25od w=33u l=0.5u
M_51 PAD net_1685 net_1683 VSS nch_25od w=33u l=0.5u
M_52 PAD net_1685 net_1684 VSS nch_25od w=33u l=0.5u
M_53 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_54 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_55 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_56 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_57 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_58 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_59 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_60 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_61 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_62 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_63 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_64 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_65 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_66 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_67 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_68 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_69 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_70 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_71 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_72 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_73 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_74 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_75 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_76 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_77 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_78 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_79 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_80 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_81 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_82 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_83 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_84 PAD net_1672 VDDPST net_1672 pch_25od w=16.5u l=0.415u
M_85 net_1686 net_1687 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1672 net_1672 net_1672 net_1672 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1688 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_1689 net_1690 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_1689 net_1686 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1690 net_1686 net_1689 VSS nch_25od w=5u l=0.5u
M_91 net_1691 net_1690 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1690 net_1686 net_1691 VDDPST pch_25od w=5u l=0.415u
M_93 net_1691 net_1692 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1693 net_1694 net_1695 VDDPST pch_25od w=20u l=0.415u
M_95 net_1693 net_1696 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1695 net_1696 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1694 net_1695 VSS nch_25od w=15u l=0.5u
M_98 net_1697 net_1698 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1699 net_1700 net_1701 VSS nch_25od w=10u l=0.5u
M_100 VSS net_1702 net_1703 VSS nch_25od w=10u l=0.5u
M_101 net_1704 net_1700 net_1705 VSS nch_25od w=10u l=0.5u
M_102 net_1703 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1703 net_1697 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1703 net_1697 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_1702 net_1705 VSS nch w=10u l=0.09u
M_106 net_1699 net_1698 VSS VSS nch w=10u l=0.09u
M_107 net_1704 net_1702 net_1703 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1697 net_1698 net_1701 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1706 net_1707 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1708 net_1700 net_1709 VSS nch_25od w=10u l=0.5u
M_111 VSS net_1710 net_1711 VSS nch_25od w=10u l=0.5u
M_112 net_1712 net_1700 net_1713 VSS nch_25od w=10u l=0.5u
M_113 net_1711 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1711 net_1706 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1711 net_1706 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_1710 net_1713 VSS nch w=10u l=0.09u
M_117 net_1708 net_1707 VSS VSS nch w=10u l=0.09u
M_118 net_1712 net_1710 net_1711 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1706 net_1707 net_1709 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1714 net_1715 VDDPST pch_25od w=40u l=0.415u
M_121 net_1715 net_1716 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1717 net_1714 net_1715 VSS nch_25od w=20u l=0.5u
M_123 net_1717 net_1716 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1710 net_1702 VSS nch w=3u l=0.1u
M_125 net_1710 net_1702 VDD VDD pch w=4u l=0.1u
M_126 net_1702 net_1710 net_1710 VDD pch w=4u l=0.1u
M_127 net_1687 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1688 net_1718 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1687 net_1702 VSS VSS nch_25od w=20u l=0.5u
M_130 net_1687 net_1688 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1688 net_1687 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1700 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1700 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1692 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1671 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1719 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1685 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_1702 ndio area=4p
D_139 VSS net_1710 ndio area=4p
D_140 VSS net_1702 ndio area=4p
M_141 net_1720 net_1697 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1720 net_1697 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1716 net_1706 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1716 net_1706 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1694 net_1703 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1694 net_1703 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1714 net_1720 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1714 net_1720 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1696 net_1711 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1696 net_1711 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1698 net_1702 VSS VSS nch w=3u l=0.09u
M_152 net_1698 net_1702 VDD VDD pch w=7.5u l=0.09u
M_153 net_1707 net_1710 VSS VSS nch w=3u l=0.09u
M_154 net_1707 net_1710 VDD VDD pch w=7.5u l=0.09u
M_155 net_1718 net_1702 VSS VSS nch w=3u l=0.09u
M_156 net_1718 net_1702 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1721 C VSS nch w=20u l=0.09u
M_158 VSS net_1722 net_1721 VSS nch w=10u l=0.09u
M_159 VDD net_1721 C VDD pch w=30u l=0.09u
M_160 VDD net_1722 net_1721 VDD pch w=10u l=0.09u
M_161 VSS net_1690 net_1723 VSS nch_25od w=0.6u l=0.5u
M_162 net_1722 net_1723 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1724 net_1716 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1725 net_1719 net_1724 VSS nch_25od w=10u l=0.5u
M_165 net_1726 net_1719 net_1715 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1690 net_1722 VSS nch_25od w=5u l=0.5u
M_167 net_1692 net_1719 net_1686 VSS nch_25od w=30u l=0.5u
M_168 net_1727 net_1719 net_1725 VSS nch_25od w=10u l=0.5u
M_169 net_1686 net_1696 net_1727 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1690 net_1723 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1725 net_1719 net_1692 net_1672 pch_25od w=26u l=0.415u
M_172 net_1726 net_1725 net_1715 net_1672 pch_25od w=26u l=0.415u
M_173 VDD net_1690 net_1722 VDD pch_25od w=5u l=0.415u
M_174 net_1672 net_1725 VDDPST net_1672 pch_25od w=24u l=0.415u
M_175 net_1672 net_1719 net_1692 net_1672 pch_25od w=24u l=0.415u
M_176 net_1726 net_1719 net_1692 net_1672 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDSDGZ
.SUBCKT PDDW02DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1729 net_1729 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1729 net_1729 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1728 net_1728 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_14 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_15 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_16 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_17 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_18 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_19 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_20 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_21 net_1731 net_1731 rppolywo w=0.4u l=1.3u m=1
X_22 net_1731 net_1731 rppolywo w=0.4u l=1.3u m=1
X_23 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_24 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_25 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_26 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_27 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
X_28 net_1730 net_1730 rppolywo w=0.4u l=1.3u m=1
M_29 net_1732 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1733 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1734 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1735 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1736 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1737 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1738 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1739 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1740 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1741 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_39 net_1742 net_1728 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_1743 net_1732 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1743 net_1733 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1743 net_1734 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1743 net_1735 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1743 net_1736 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1743 net_1737 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1743 net_1738 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1743 net_1739 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1743 net_1740 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1743 net_1741 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1743 net_1742 VSS nch_25od w=33u l=0.5u
M_51 PAD net_1743 net_1744 VSS nch_25od w=33u l=0.5u
M_52 net_1744 net_1729 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_54 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_55 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_56 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_57 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_58 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_59 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_60 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_61 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_62 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_63 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_64 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_65 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_66 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_67 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_68 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_69 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_70 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_71 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_72 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_73 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_74 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_75 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_76 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_77 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_78 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_79 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_80 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_81 PAD net_1730 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_82 PAD net_1731 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_83 PAD net_1731 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_84 PAD net_1731 VDDPST net_1730 pch_25od w=16.5u l=0.415u
M_85 net_1745 net_1746 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1730 net_1730 net_1730 net_1730 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1747 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1748 net_1745 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1749 net_1745 net_1748 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1749 net_1745 net_1750 VDDPST pch_25od w=5u l=0.415u
M_93 net_1750 net_1751 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1752 net_1753 net_1729 VDDPST pch_25od w=20u l=0.415u
M_95 net_1752 net_1754 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1729 net_1754 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1753 net_1729 VSS nch_25od w=15u l=0.5u
M_98 net_1755 net_1756 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1757 net_1758 net_1759 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1760 VSS nch_25od w=10u l=0.5u
M_101 net_1761 net_1758 net_1762 VSS nch_25od w=10u l=0.5u
M_102 net_1760 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1760 net_1755 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1760 net_1755 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1762 VSS nch w=10u l=0.09u
M_106 net_1757 net_1756 VSS VSS nch w=10u l=0.09u
M_107 net_1761 I net_1760 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1755 net_1756 net_1759 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1763 net_1764 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1765 net_1758 net_1766 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1767 VSS nch_25od w=10u l=0.5u
M_112 net_1768 net_1758 net_1769 VSS nch_25od w=10u l=0.5u
M_113 net_1767 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1767 net_1763 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1767 net_1763 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1769 VSS nch w=10u l=0.09u
M_117 net_1765 net_1764 VSS VSS nch w=10u l=0.09u
M_118 net_1768 OEN net_1767 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1763 net_1764 net_1766 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1770 net_1771 VDDPST pch_25od w=40u l=0.415u
M_121 net_1771 net_1772 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1773 net_1770 net_1771 VSS nch_25od w=20u l=0.5u
M_123 net_1773 net_1772 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1774 net_1775 VSS nch w=3u l=0.1u
M_125 net_1774 net_1775 VDD VDD pch w=4u l=0.1u
M_126 net_1775 net_1774 net_1774 VDD pch w=4u l=0.1u
M_127 net_1746 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1747 net_1776 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1746 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_1746 net_1747 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1747 net_1746 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1758 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1758 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1751 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1728 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1777 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1743 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1778 net_1755 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1778 net_1755 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1772 net_1763 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1772 net_1763 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1753 net_1760 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1753 net_1760 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1770 net_1778 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1770 net_1778 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1754 net_1767 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1754 net_1767 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1756 I VSS VSS nch w=3u l=0.09u
M_152 net_1756 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1764 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1764 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1776 REN VSS VSS nch w=3u l=0.09u
M_156 net_1776 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1779 C VSS nch w=20u l=0.09u
M_158 VSS net_1780 net_1779 VSS nch w=10u l=0.09u
M_159 VDD net_1779 C VDD pch w=30u l=0.09u
M_160 VDD net_1780 net_1779 VDD pch w=10u l=0.09u
M_161 VSS net_1749 net_1781 VSS nch_25od w=0.6u l=0.5u
M_162 net_1780 net_1781 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1782 net_1772 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1783 net_1777 net_1782 VSS nch_25od w=10u l=0.5u
M_165 net_1731 net_1777 net_1771 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1749 net_1780 VSS nch_25od w=5u l=0.5u
M_167 net_1751 net_1777 net_1745 VSS nch_25od w=30u l=0.5u
M_168 net_1784 net_1777 net_1783 VSS nch_25od w=10u l=0.5u
M_169 net_1745 net_1754 net_1784 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1749 net_1781 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1783 net_1777 net_1751 net_1730 pch_25od w=26u l=0.415u
M_172 net_1731 net_1783 net_1771 net_1730 pch_25od w=26u l=0.415u
M_173 VDD net_1749 net_1780 VDD pch_25od w=5u l=0.415u
M_174 net_1730 net_1783 VDDPST net_1730 pch_25od w=24u l=0.415u
M_175 net_1730 net_1777 net_1751 net_1730 pch_25od w=24u l=0.415u
M_176 net_1731 net_1777 net_1751 net_1730 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW02DGZ
.SUBCKT PDDW04DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1786 net_1786 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1786 net_1786 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1785 net_1785 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_14 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_15 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_16 net_1788 net_1788 rppolywo w=0.4u l=1.3u m=1
X_17 net_1788 net_1788 rppolywo w=0.4u l=1.3u m=1
X_18 net_1788 net_1788 rppolywo w=0.4u l=1.3u m=1
X_19 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_20 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_21 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_22 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_23 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_24 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_25 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_26 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_27 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
X_28 net_1787 net_1787 rppolywo w=0.4u l=1.3u m=1
M_29 net_1789 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1790 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1791 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1792 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1793 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1794 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1795 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1796 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_37 net_1797 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_38 net_1798 net_1785 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_1799 net_1789 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1799 net_1790 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1799 net_1791 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1799 net_1792 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1799 net_1793 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1799 net_1794 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1799 net_1795 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1799 net_1796 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1799 net_1797 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1799 net_1798 VSS nch_25od w=33u l=0.5u
M_49 PAD net_1799 net_1800 VSS nch_25od w=33u l=0.5u
M_50 PAD net_1799 net_1801 VSS nch_25od w=33u l=0.5u
M_51 net_1800 net_1786 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1801 net_1786 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_54 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_55 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_56 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_57 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_58 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_59 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_60 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_61 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_62 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_63 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_64 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_65 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_66 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_67 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_68 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_69 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_70 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_71 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_72 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_73 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_74 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_75 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_76 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_77 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_78 PAD net_1787 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_79 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_80 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_81 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_82 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_83 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_84 PAD net_1788 VDDPST net_1787 pch_25od w=16.5u l=0.415u
M_85 net_1802 net_1803 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1787 net_1787 net_1787 net_1787 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1804 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1805 net_1802 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1806 net_1802 net_1805 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1806 net_1802 net_1807 VDDPST pch_25od w=5u l=0.415u
M_93 net_1807 net_1808 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1809 net_1810 net_1786 VDDPST pch_25od w=20u l=0.415u
M_95 net_1809 net_1811 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1786 net_1811 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1810 net_1786 VSS nch_25od w=15u l=0.5u
M_98 net_1812 net_1813 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1814 net_1815 net_1816 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1817 VSS nch_25od w=10u l=0.5u
M_101 net_1818 net_1815 net_1819 VSS nch_25od w=10u l=0.5u
M_102 net_1817 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1817 net_1812 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1817 net_1812 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1819 VSS nch w=10u l=0.09u
M_106 net_1814 net_1813 VSS VSS nch w=10u l=0.09u
M_107 net_1818 I net_1817 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1812 net_1813 net_1816 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1820 net_1821 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1822 net_1815 net_1823 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1824 VSS nch_25od w=10u l=0.5u
M_112 net_1825 net_1815 net_1826 VSS nch_25od w=10u l=0.5u
M_113 net_1824 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1824 net_1820 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1824 net_1820 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1826 VSS nch w=10u l=0.09u
M_117 net_1822 net_1821 VSS VSS nch w=10u l=0.09u
M_118 net_1825 OEN net_1824 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1820 net_1821 net_1823 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1827 net_1828 VDDPST pch_25od w=40u l=0.415u
M_121 net_1828 net_1829 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1830 net_1827 net_1828 VSS nch_25od w=20u l=0.5u
M_123 net_1830 net_1829 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1831 net_1832 VSS nch w=3u l=0.1u
M_125 net_1831 net_1832 VDD VDD pch w=4u l=0.1u
M_126 net_1832 net_1831 net_1831 VDD pch w=4u l=0.1u
M_127 net_1803 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1804 net_1833 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1803 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_1803 net_1804 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1804 net_1803 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1815 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1815 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1808 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1785 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1834 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1799 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1835 net_1812 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1835 net_1812 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1829 net_1820 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1829 net_1820 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1810 net_1817 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1810 net_1817 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1827 net_1835 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1827 net_1835 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1811 net_1824 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1811 net_1824 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1813 I VSS VSS nch w=3u l=0.09u
M_152 net_1813 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1821 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1821 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1833 REN VSS VSS nch w=3u l=0.09u
M_156 net_1833 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1836 C VSS nch w=20u l=0.09u
M_158 VSS net_1837 net_1836 VSS nch w=10u l=0.09u
M_159 VDD net_1836 C VDD pch w=30u l=0.09u
M_160 VDD net_1837 net_1836 VDD pch w=10u l=0.09u
M_161 VSS net_1806 net_1838 VSS nch_25od w=0.6u l=0.5u
M_162 net_1837 net_1838 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1839 net_1829 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1840 net_1834 net_1839 VSS nch_25od w=10u l=0.5u
M_165 net_1788 net_1834 net_1828 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1806 net_1837 VSS nch_25od w=5u l=0.5u
M_167 net_1808 net_1834 net_1802 VSS nch_25od w=30u l=0.5u
M_168 net_1841 net_1834 net_1840 VSS nch_25od w=10u l=0.5u
M_169 net_1802 net_1811 net_1841 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1806 net_1838 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1840 net_1834 net_1808 net_1787 pch_25od w=26u l=0.415u
M_172 net_1788 net_1840 net_1828 net_1787 pch_25od w=26u l=0.415u
M_173 VDD net_1806 net_1837 VDD pch_25od w=5u l=0.415u
M_174 net_1787 net_1840 VDDPST net_1787 pch_25od w=24u l=0.415u
M_175 net_1787 net_1834 net_1808 net_1787 pch_25od w=24u l=0.415u
M_176 net_1788 net_1834 net_1808 net_1787 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW04DGZ
.SUBCKT PDDW08DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1843 net_1843 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1843 net_1843 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1843 net_1843 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1843 net_1843 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1842 net_1842 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_14 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_15 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_16 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_17 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_18 net_1844 net_1844 rppolywo w=0.4u l=1.3u m=1
X_19 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_20 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_21 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_22 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_23 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_24 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_25 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_26 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_27 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
X_28 net_1845 net_1845 rppolywo w=0.4u l=1.3u m=1
M_29 net_1846 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1847 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1848 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1849 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1850 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1851 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_35 net_1852 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_36 net_1853 net_1842 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_1854 net_1846 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1854 net_1847 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1854 net_1848 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1854 net_1849 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1854 net_1850 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1854 net_1851 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1854 net_1852 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1854 net_1853 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1854 net_1855 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1854 net_1856 VSS nch_25od w=33u l=0.5u
M_47 PAD net_1854 net_1857 VSS nch_25od w=33u l=0.5u
M_48 PAD net_1854 net_1858 VSS nch_25od w=33u l=0.5u
M_49 net_1855 net_1843 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1856 net_1843 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1857 net_1843 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1858 net_1843 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_54 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_55 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_56 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_57 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_58 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_59 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_60 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_61 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_62 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_63 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_64 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_65 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_66 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_67 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_68 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_69 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_70 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_71 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_72 PAD net_1845 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_73 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_74 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_75 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_76 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_77 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_78 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_79 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_80 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_81 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_82 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_83 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_84 PAD net_1844 VDDPST net_1845 pch_25od w=16.5u l=0.415u
M_85 net_1859 net_1860 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1845 net_1845 net_1845 net_1845 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1861 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1862 net_1859 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1863 net_1859 net_1862 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1863 net_1859 net_1864 VDDPST pch_25od w=5u l=0.415u
M_93 net_1864 net_1865 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1866 net_1867 net_1843 VDDPST pch_25od w=20u l=0.415u
M_95 net_1866 net_1868 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1843 net_1868 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1867 net_1843 VSS nch_25od w=15u l=0.5u
M_98 net_1869 net_1870 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1871 net_1872 net_1873 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1874 VSS nch_25od w=10u l=0.5u
M_101 net_1875 net_1872 net_1876 VSS nch_25od w=10u l=0.5u
M_102 net_1874 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1874 net_1869 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1874 net_1869 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1876 VSS nch w=10u l=0.09u
M_106 net_1871 net_1870 VSS VSS nch w=10u l=0.09u
M_107 net_1875 I net_1874 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1869 net_1870 net_1873 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1877 net_1878 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1879 net_1872 net_1880 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1881 VSS nch_25od w=10u l=0.5u
M_112 net_1882 net_1872 net_1883 VSS nch_25od w=10u l=0.5u
M_113 net_1881 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1881 net_1877 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1881 net_1877 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1883 VSS nch w=10u l=0.09u
M_117 net_1879 net_1878 VSS VSS nch w=10u l=0.09u
M_118 net_1882 OEN net_1881 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1877 net_1878 net_1880 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1884 net_1885 VDDPST pch_25od w=40u l=0.415u
M_121 net_1885 net_1886 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1887 net_1884 net_1885 VSS nch_25od w=20u l=0.5u
M_123 net_1887 net_1886 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1888 net_1889 VSS nch w=3u l=0.1u
M_125 net_1888 net_1889 VDD VDD pch w=4u l=0.1u
M_126 net_1889 net_1888 net_1888 VDD pch w=4u l=0.1u
M_127 net_1860 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1861 net_1890 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1860 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_1860 net_1861 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1861 net_1860 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1872 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1872 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1865 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1842 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1891 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1854 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1892 net_1869 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1892 net_1869 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1886 net_1877 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1886 net_1877 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1867 net_1874 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1867 net_1874 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1884 net_1892 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1884 net_1892 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1868 net_1881 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1868 net_1881 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1870 I VSS VSS nch w=3u l=0.09u
M_152 net_1870 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1878 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1878 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1890 REN VSS VSS nch w=3u l=0.09u
M_156 net_1890 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1893 C VSS nch w=20u l=0.09u
M_158 VSS net_1894 net_1893 VSS nch w=10u l=0.09u
M_159 VDD net_1893 C VDD pch w=30u l=0.09u
M_160 VDD net_1894 net_1893 VDD pch w=10u l=0.09u
M_161 VSS net_1863 net_1895 VSS nch_25od w=0.6u l=0.5u
M_162 net_1894 net_1895 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1896 net_1886 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1897 net_1891 net_1896 VSS nch_25od w=10u l=0.5u
M_165 net_1844 net_1891 net_1885 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1863 net_1894 VSS nch_25od w=5u l=0.5u
M_167 net_1865 net_1891 net_1859 VSS nch_25od w=30u l=0.5u
M_168 net_1898 net_1891 net_1897 VSS nch_25od w=10u l=0.5u
M_169 net_1859 net_1868 net_1898 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1863 net_1895 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1897 net_1891 net_1865 net_1845 pch_25od w=26u l=0.415u
M_172 net_1844 net_1897 net_1885 net_1845 pch_25od w=26u l=0.415u
M_173 VDD net_1863 net_1894 VDD pch_25od w=5u l=0.415u
M_174 net_1845 net_1897 VDDPST net_1845 pch_25od w=24u l=0.415u
M_175 net_1845 net_1891 net_1865 net_1845 pch_25od w=24u l=0.415u
M_176 net_1844 net_1891 net_1865 net_1845 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW08DGZ
.SUBCKT PDDW12DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1899 net_1899 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1900 net_1900 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_14 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_15 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_16 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_17 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_18 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_19 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_20 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_21 net_1901 net_1901 rppolywo w=0.4u l=1.3u m=1
X_22 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_23 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_24 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_25 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_26 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_27 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
X_28 net_1902 net_1902 rppolywo w=0.4u l=1.3u m=1
M_29 net_1903 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1904 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1905 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1906 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_33 net_1907 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_34 net_1908 net_1900 VSS VSS nch_25od w=33u l=0.5u
M_35 PAD net_1909 net_1903 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1909 net_1904 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1909 net_1905 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1909 net_1906 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1909 net_1907 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1909 net_1908 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1909 net_1910 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1909 net_1911 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1909 net_1912 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1909 net_1913 VSS nch_25od w=33u l=0.5u
M_45 PAD net_1909 net_1914 VSS nch_25od w=33u l=0.5u
M_46 PAD net_1909 net_1915 VSS nch_25od w=33u l=0.5u
M_47 net_1910 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1911 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1912 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1913 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1914 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1915 net_1899 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_54 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_55 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_56 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_57 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_58 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_59 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_60 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_61 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_62 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_63 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_64 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_65 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_66 PAD net_1902 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_67 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_68 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_69 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_70 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_71 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_72 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_73 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_74 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_75 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_76 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_77 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_78 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_79 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_80 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_81 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_82 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_83 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_84 PAD net_1901 VDDPST net_1902 pch_25od w=16.5u l=0.415u
M_85 net_1916 net_1917 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1902 net_1902 net_1902 net_1902 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1918 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1919 net_1916 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1920 net_1916 net_1919 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1920 net_1916 net_1921 VDDPST pch_25od w=5u l=0.415u
M_93 net_1921 net_1922 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1923 net_1924 net_1899 VDDPST pch_25od w=20u l=0.415u
M_95 net_1923 net_1925 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1899 net_1925 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1924 net_1899 VSS nch_25od w=15u l=0.5u
M_98 net_1926 net_1927 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1928 net_1929 net_1930 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1931 VSS nch_25od w=10u l=0.5u
M_101 net_1932 net_1929 net_1933 VSS nch_25od w=10u l=0.5u
M_102 net_1931 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1931 net_1926 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1931 net_1926 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1933 VSS nch w=10u l=0.09u
M_106 net_1928 net_1927 VSS VSS nch w=10u l=0.09u
M_107 net_1932 I net_1931 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1926 net_1927 net_1930 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1934 net_1935 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1936 net_1929 net_1937 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1938 VSS nch_25od w=10u l=0.5u
M_112 net_1939 net_1929 net_1940 VSS nch_25od w=10u l=0.5u
M_113 net_1938 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1938 net_1934 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1938 net_1934 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1940 VSS nch w=10u l=0.09u
M_117 net_1936 net_1935 VSS VSS nch w=10u l=0.09u
M_118 net_1939 OEN net_1938 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1934 net_1935 net_1937 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1941 net_1942 VDDPST pch_25od w=40u l=0.415u
M_121 net_1942 net_1943 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_1944 net_1941 net_1942 VSS nch_25od w=20u l=0.5u
M_123 net_1944 net_1943 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_1945 net_1946 VSS nch w=3u l=0.1u
M_125 net_1945 net_1946 VDD VDD pch w=4u l=0.1u
M_126 net_1946 net_1945 net_1945 VDD pch w=4u l=0.1u
M_127 net_1917 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1918 net_1947 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1917 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_1917 net_1918 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1918 net_1917 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1929 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1929 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1922 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1900 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_1948 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1909 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_1949 net_1926 VSS VSS nch_25od w=2u l=0.5u
M_142 net_1949 net_1926 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_1943 net_1934 VSS VSS nch_25od w=3u l=0.5u
M_144 net_1943 net_1934 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1924 net_1931 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1924 net_1931 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1941 net_1949 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1941 net_1949 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1925 net_1938 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1925 net_1938 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1927 I VSS VSS nch w=3u l=0.09u
M_152 net_1927 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1935 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1935 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_1947 REN VSS VSS nch w=3u l=0.09u
M_156 net_1947 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_1950 C VSS nch w=20u l=0.09u
M_158 VSS net_1951 net_1950 VSS nch w=10u l=0.09u
M_159 VDD net_1950 C VDD pch w=30u l=0.09u
M_160 VDD net_1951 net_1950 VDD pch w=10u l=0.09u
M_161 VSS net_1920 net_1952 VSS nch_25od w=0.6u l=0.5u
M_162 net_1951 net_1952 VDD VSS nch_25od w=5u l=0.5u
M_163 net_1953 net_1943 VSS VSS nch_25od w=10u l=0.5u
M_164 net_1954 net_1948 net_1953 VSS nch_25od w=10u l=0.5u
M_165 net_1901 net_1948 net_1942 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1920 net_1951 VSS nch_25od w=5u l=0.5u
M_167 net_1922 net_1948 net_1916 VSS nch_25od w=30u l=0.5u
M_168 net_1955 net_1948 net_1954 VSS nch_25od w=10u l=0.5u
M_169 net_1916 net_1925 net_1955 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1920 net_1952 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_1954 net_1948 net_1922 net_1902 pch_25od w=26u l=0.415u
M_172 net_1901 net_1954 net_1942 net_1902 pch_25od w=26u l=0.415u
M_173 VDD net_1920 net_1951 VDD pch_25od w=5u l=0.415u
M_174 net_1902 net_1954 VDDPST net_1902 pch_25od w=24u l=0.415u
M_175 net_1902 net_1948 net_1922 net_1902 pch_25od w=24u l=0.415u
M_176 net_1901 net_1948 net_1922 net_1902 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW12DGZ
.SUBCKT PDDW16DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_1956 net_1956 rnpolywo w=0.4u l=2.93u m=1
X_2 net_1956 net_1956 rnpolywo w=0.4u l=2.93u m=1
X_3 net_1956 net_1956 rnpolywo w=0.4u l=2.93u m=1
X_4 net_1956 net_1956 rnpolywo w=0.4u l=2.93u m=1
X_5 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_6 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_7 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_8 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_9 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_10 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_11 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_12 net_1957 net_1957 rnpolywo w=0.4u l=2.93u m=1
X_13 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_14 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_15 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_16 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_17 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_18 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_19 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_20 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_21 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_22 net_1959 net_1959 rppolywo w=0.4u l=1.3u m=1
X_23 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_24 net_1959 net_1959 rppolywo w=0.4u l=1.3u m=1
X_25 net_1959 net_1959 rppolywo w=0.4u l=1.3u m=1
X_26 net_1959 net_1959 rppolywo w=0.4u l=1.3u m=1
X_27 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
X_28 net_1958 net_1958 rppolywo w=0.4u l=1.3u m=1
M_29 net_1960 net_1956 VSS VSS nch_25od w=33u l=0.5u
M_30 net_1961 net_1956 VSS VSS nch_25od w=33u l=0.5u
M_31 net_1962 net_1956 VSS VSS nch_25od w=33u l=0.5u
M_32 net_1963 net_1956 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_1964 net_1960 VSS nch_25od w=33u l=0.5u
M_34 PAD net_1964 net_1961 VSS nch_25od w=33u l=0.5u
M_35 PAD net_1964 net_1962 VSS nch_25od w=33u l=0.5u
M_36 PAD net_1964 net_1963 VSS nch_25od w=33u l=0.5u
M_37 PAD net_1964 net_1965 VSS nch_25od w=33u l=0.5u
M_38 PAD net_1964 net_1966 VSS nch_25od w=33u l=0.5u
M_39 PAD net_1964 net_1967 VSS nch_25od w=33u l=0.5u
M_40 PAD net_1964 net_1968 VSS nch_25od w=33u l=0.5u
M_41 PAD net_1964 net_1969 VSS nch_25od w=33u l=0.5u
M_42 PAD net_1964 net_1970 VSS nch_25od w=33u l=0.5u
M_43 PAD net_1964 net_1971 VSS nch_25od w=33u l=0.5u
M_44 PAD net_1964 net_1972 VSS nch_25od w=33u l=0.5u
M_45 net_1965 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_46 net_1966 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_47 net_1967 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_48 net_1968 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_49 net_1969 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_50 net_1970 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_51 net_1971 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_52 net_1972 net_1957 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_54 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_55 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_56 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_57 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_58 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_59 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_60 PAD net_1959 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_61 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_62 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_63 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_64 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_65 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_66 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_67 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_68 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_69 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_70 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_71 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_72 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_73 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_74 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_75 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_76 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_77 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_78 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_79 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_80 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_81 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_82 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_83 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_84 PAD net_1958 VDDPST net_1959 pch_25od w=16.5u l=0.415u
M_85 net_1973 net_1974 VSS VSS nch_25od w=0.5u l=3u
M_86 net_1959 net_1959 net_1959 net_1959 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_1975 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_1976 net_1973 VSS VSS nch_25od w=5u l=0.5u
M_90 net_1977 net_1973 net_1976 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_1977 net_1973 net_1978 VDDPST pch_25od w=5u l=0.415u
M_93 net_1978 net_1979 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_1980 net_1981 net_1957 VDDPST pch_25od w=20u l=0.415u
M_95 net_1980 net_1982 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_1957 net_1982 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_1981 net_1957 VSS nch_25od w=15u l=0.5u
M_98 net_1983 net_1984 VSS VSS nch_25od w=10u l=0.5u
M_99 net_1985 net_1986 net_1987 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_1988 VSS nch_25od w=10u l=0.5u
M_101 net_1989 net_1986 net_1990 VSS nch_25od w=10u l=0.5u
M_102 net_1988 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_1988 net_1983 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_1988 net_1983 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_1990 VSS nch w=10u l=0.09u
M_106 net_1985 net_1984 VSS VSS nch w=10u l=0.09u
M_107 net_1989 I net_1988 VSS nch_na25 w=5.5u l=1.32u
M_108 net_1983 net_1984 net_1987 VSS nch_na25 w=5.5u l=1.32u
M_109 net_1991 net_1992 VSS VSS nch_25od w=10u l=0.5u
M_110 net_1993 net_1986 net_1994 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_1995 VSS nch_25od w=10u l=0.5u
M_112 net_1996 net_1986 net_1997 VSS nch_25od w=10u l=0.5u
M_113 net_1995 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_1995 net_1991 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_1995 net_1991 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_1997 VSS nch w=10u l=0.09u
M_117 net_1993 net_1992 VSS VSS nch w=10u l=0.09u
M_118 net_1996 OEN net_1995 VSS nch_na25 w=5.5u l=1.32u
M_119 net_1991 net_1992 net_1994 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_1998 net_1999 VDDPST pch_25od w=40u l=0.415u
M_121 net_1999 net_2000 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2001 net_1998 net_1999 VSS nch_25od w=20u l=0.5u
M_123 net_2001 net_2000 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2002 net_2003 VSS nch w=3u l=0.1u
M_125 net_2002 net_2003 VDD VDD pch w=4u l=0.1u
M_126 net_2003 net_2002 net_2002 VDD pch w=4u l=0.1u
M_127 net_1974 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_1975 net_2004 VSS VSS nch_25od w=20u l=0.5u
M_129 net_1974 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_1974 net_1975 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_1975 net_1974 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_1986 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_1986 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_1979 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_1956 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2005 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_1964 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2006 net_1983 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2006 net_1983 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2000 net_1991 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2000 net_1991 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_1981 net_1988 VSS VSS nch_25od w=7u l=0.5u
M_146 net_1981 net_1988 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_1998 net_2006 VSS VSS nch_25od w=10u l=0.5u
M_148 net_1998 net_2006 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_1982 net_1995 VSS VSS nch_25od w=3u l=0.5u
M_150 net_1982 net_1995 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_1984 I VSS VSS nch w=3u l=0.09u
M_152 net_1984 I VDD VDD pch w=7.5u l=0.09u
M_153 net_1992 OEN VSS VSS nch w=3u l=0.09u
M_154 net_1992 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2004 REN VSS VSS nch w=3u l=0.09u
M_156 net_2004 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2007 C VSS nch w=20u l=0.09u
M_158 VSS net_2008 net_2007 VSS nch w=10u l=0.09u
M_159 VDD net_2007 C VDD pch w=30u l=0.09u
M_160 VDD net_2008 net_2007 VDD pch w=10u l=0.09u
M_161 VSS net_1977 net_2009 VSS nch_25od w=0.6u l=0.5u
M_162 net_2008 net_2009 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2010 net_2000 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2011 net_2005 net_2010 VSS nch_25od w=10u l=0.5u
M_165 net_1958 net_2005 net_1999 VSS nch_25od w=30u l=0.5u
M_166 VSS net_1977 net_2008 VSS nch_25od w=5u l=0.5u
M_167 net_1979 net_2005 net_1973 VSS nch_25od w=30u l=0.5u
M_168 net_2012 net_2005 net_2011 VSS nch_25od w=10u l=0.5u
M_169 net_1973 net_1982 net_2012 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_1977 net_2009 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2011 net_2005 net_1979 net_1959 pch_25od w=26u l=0.415u
M_172 net_1958 net_2011 net_1999 net_1959 pch_25od w=26u l=0.415u
M_173 VDD net_1977 net_2008 VDD pch_25od w=5u l=0.415u
M_174 net_1959 net_2011 VDDPST net_1959 pch_25od w=24u l=0.415u
M_175 net_1959 net_2005 net_1979 net_1959 pch_25od w=24u l=0.415u
M_176 net_1958 net_2005 net_1979 net_1959 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW16DGZ
.SUBCKT PDDW24DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2013 net_2013 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_14 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_15 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_16 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_17 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_18 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_19 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_20 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_21 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_22 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_23 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_24 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_25 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_26 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_27 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
X_28 net_2014 net_2014 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_2015 net_2016 VSS nch_25od w=33u l=0.5u
M_30 PAD net_2015 net_2017 VSS nch_25od w=33u l=0.5u
M_31 PAD net_2015 net_2018 VSS nch_25od w=33u l=0.5u
M_32 PAD net_2015 net_2019 VSS nch_25od w=33u l=0.5u
M_33 PAD net_2015 net_2020 VSS nch_25od w=33u l=0.5u
M_34 PAD net_2015 net_2021 VSS nch_25od w=33u l=0.5u
M_35 PAD net_2015 net_2022 VSS nch_25od w=33u l=0.5u
M_36 PAD net_2015 net_2023 VSS nch_25od w=33u l=0.5u
M_37 PAD net_2015 net_2024 VSS nch_25od w=33u l=0.5u
M_38 PAD net_2015 net_2025 VSS nch_25od w=33u l=0.5u
M_39 PAD net_2015 net_2026 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2015 net_2027 VSS nch_25od w=33u l=0.5u
M_41 net_2016 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_42 net_2017 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_43 net_2018 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_44 net_2019 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_45 net_2020 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_46 net_2021 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_47 net_2022 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_48 net_2023 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_49 net_2024 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_50 net_2025 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_51 net_2026 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2027 net_2013 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_54 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_55 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_56 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_57 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_58 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_59 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_60 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_61 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_62 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_63 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_64 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_65 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_66 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_67 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_68 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_69 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_70 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_71 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_72 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_73 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_74 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_75 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_76 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_77 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_78 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_79 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_80 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_81 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_82 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_83 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_84 PAD net_2014 VDDPST net_2028 pch_25od w=16.5u l=0.415u
M_85 net_2029 net_2030 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2028 net_2028 net_2028 net_2028 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2031 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_2032 net_2029 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2033 net_2029 net_2032 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2033 net_2029 net_2034 VDDPST pch_25od w=5u l=0.415u
M_93 net_2034 net_2035 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2036 net_2037 net_2013 VDDPST pch_25od w=20u l=0.415u
M_95 net_2036 net_2038 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2013 net_2038 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2037 net_2013 VSS nch_25od w=15u l=0.5u
M_98 net_2039 net_2040 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2041 net_2042 net_2043 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2044 VSS nch_25od w=10u l=0.5u
M_101 net_2045 net_2042 net_2046 VSS nch_25od w=10u l=0.5u
M_102 net_2044 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2044 net_2039 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2044 net_2039 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2046 VSS nch w=10u l=0.09u
M_106 net_2041 net_2040 VSS VSS nch w=10u l=0.09u
M_107 net_2045 I net_2044 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2039 net_2040 net_2043 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2047 net_2048 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2049 net_2042 net_2050 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_2051 VSS nch_25od w=10u l=0.5u
M_112 net_2052 net_2042 net_2053 VSS nch_25od w=10u l=0.5u
M_113 net_2051 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2051 net_2047 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2051 net_2047 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_2053 VSS nch w=10u l=0.09u
M_117 net_2049 net_2048 VSS VSS nch w=10u l=0.09u
M_118 net_2052 OEN net_2051 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2047 net_2048 net_2050 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2054 net_2055 VDDPST pch_25od w=40u l=0.415u
M_121 net_2055 net_2056 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2057 net_2054 net_2055 VSS nch_25od w=20u l=0.5u
M_123 net_2057 net_2056 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2058 net_2059 VSS nch w=3u l=0.1u
M_125 net_2058 net_2059 VDD VDD pch w=4u l=0.1u
M_126 net_2059 net_2058 net_2058 VDD pch w=4u l=0.1u
M_127 net_2030 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2031 net_2060 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2030 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_2030 net_2031 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2031 net_2030 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2042 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2042 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2035 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2061 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2062 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2015 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2063 net_2039 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2063 net_2039 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2056 net_2047 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2056 net_2047 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2037 net_2044 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2037 net_2044 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2054 net_2063 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2054 net_2063 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2038 net_2051 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2038 net_2051 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2040 I VSS VSS nch w=3u l=0.09u
M_152 net_2040 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2048 OEN VSS VSS nch w=3u l=0.09u
M_154 net_2048 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_2060 REN VSS VSS nch w=3u l=0.09u
M_156 net_2060 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2064 C VSS nch w=20u l=0.09u
M_158 VSS net_2065 net_2064 VSS nch w=10u l=0.09u
M_159 VDD net_2064 C VDD pch w=30u l=0.09u
M_160 VDD net_2065 net_2064 VDD pch w=10u l=0.09u
M_161 VSS net_2033 net_2066 VSS nch_25od w=0.6u l=0.5u
M_162 net_2065 net_2066 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2067 net_2056 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2068 net_2062 net_2067 VSS nch_25od w=10u l=0.5u
M_165 net_2014 net_2062 net_2055 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2033 net_2065 VSS nch_25od w=5u l=0.5u
M_167 net_2035 net_2062 net_2029 VSS nch_25od w=30u l=0.5u
M_168 net_2069 net_2062 net_2068 VSS nch_25od w=10u l=0.5u
M_169 net_2029 net_2038 net_2069 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2033 net_2066 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2068 net_2062 net_2035 net_2028 pch_25od w=26u l=0.415u
M_172 net_2014 net_2068 net_2055 net_2028 pch_25od w=26u l=0.415u
M_173 VDD net_2033 net_2065 VDD pch_25od w=5u l=0.415u
M_174 net_2028 net_2068 VDDPST net_2028 pch_25od w=24u l=0.415u
M_175 net_2028 net_2062 net_2035 net_2028 pch_25od w=24u l=0.415u
M_176 net_2014 net_2062 net_2035 net_2028 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDW24DGZ
.SUBCKT PDDWDGZ C PAD REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2070 net_2070 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_14 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_15 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_16 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_17 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_18 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_19 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_20 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_21 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_22 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_23 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_24 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_25 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_26 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_27 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
X_28 net_2071 net_2071 rppolywo w=0.4u l=1.3u m=1
M_29 net_2072 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2073 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2074 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2075 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2076 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2077 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2078 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2079 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2080 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2081 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2082 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_40 net_2083 net_2070 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_2084 net_2072 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2084 net_2073 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2084 net_2074 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2084 net_2075 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2084 net_2076 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2084 net_2077 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2084 net_2078 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2084 net_2079 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2084 net_2080 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2084 net_2081 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2084 net_2082 VSS nch_25od w=33u l=0.5u
M_52 PAD net_2084 net_2083 VSS nch_25od w=33u l=0.5u
M_53 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_54 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_55 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_56 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_57 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_58 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_59 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_60 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_61 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_62 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_63 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_64 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_65 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_66 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_67 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_68 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_69 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_70 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_71 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_72 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_73 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_74 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_75 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_76 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_77 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_78 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_79 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_80 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_81 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_82 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_83 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_84 PAD net_2071 VDDPST net_2071 pch_25od w=16.5u l=0.415u
M_85 net_2085 net_2086 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2071 net_2071 net_2071 net_2071 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2087 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_2088 net_2085 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2089 net_2085 net_2088 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2089 net_2085 net_2090 VDDPST pch_25od w=5u l=0.415u
M_93 net_2090 net_2091 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2092 net_2093 net_2094 VDDPST pch_25od w=20u l=0.415u
M_95 net_2092 net_2095 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2094 net_2095 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2093 net_2094 VSS nch_25od w=15u l=0.5u
M_98 net_2096 net_2097 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2098 net_2099 net_2100 VSS nch_25od w=10u l=0.5u
M_100 VSS net_2101 net_2102 VSS nch_25od w=10u l=0.5u
M_101 net_2103 net_2099 net_2104 VSS nch_25od w=10u l=0.5u
M_102 net_2102 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2102 net_2096 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2102 net_2096 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_2101 net_2104 VSS nch w=10u l=0.09u
M_106 net_2098 net_2097 VSS VSS nch w=10u l=0.09u
M_107 net_2103 net_2101 net_2102 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2096 net_2097 net_2100 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2105 net_2106 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2107 net_2099 net_2108 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2109 net_2110 VSS nch_25od w=10u l=0.5u
M_112 net_2111 net_2099 net_2112 VSS nch_25od w=10u l=0.5u
M_113 net_2110 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2110 net_2105 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2110 net_2105 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2109 net_2112 VSS nch w=10u l=0.09u
M_117 net_2107 net_2106 VSS VSS nch w=10u l=0.09u
M_118 net_2111 net_2109 net_2110 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2105 net_2106 net_2108 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2113 net_2114 VDDPST pch_25od w=40u l=0.415u
M_121 net_2114 net_2115 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2116 net_2113 net_2114 VSS nch_25od w=20u l=0.5u
M_123 net_2116 net_2115 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2109 net_2101 VSS nch w=3u l=0.1u
M_125 net_2109 net_2101 VDD VDD pch w=4u l=0.1u
M_126 net_2101 net_2109 net_2109 VDD pch w=4u l=0.1u
M_127 net_2086 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2087 net_2117 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2086 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_2086 net_2087 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2087 net_2086 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2099 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2099 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2091 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2070 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2118 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2084 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS net_2109 ndio area=4p
D_140 VSS net_2101 ndio area=4p
M_141 net_2119 net_2096 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2119 net_2096 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2115 net_2105 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2115 net_2105 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2093 net_2102 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2093 net_2102 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2113 net_2119 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2113 net_2119 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2095 net_2110 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2095 net_2110 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2097 net_2101 VSS VSS nch w=3u l=0.09u
M_152 net_2097 net_2101 VDD VDD pch w=7.5u l=0.09u
M_153 net_2106 net_2109 VSS VSS nch w=3u l=0.09u
M_154 net_2106 net_2109 VDD VDD pch w=7.5u l=0.09u
M_155 net_2117 REN VSS VSS nch w=3u l=0.09u
M_156 net_2117 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2120 C VSS nch w=20u l=0.09u
M_158 VSS net_2121 net_2120 VSS nch w=10u l=0.09u
M_159 VDD net_2120 C VDD pch w=30u l=0.09u
M_160 VDD net_2121 net_2120 VDD pch w=10u l=0.09u
M_161 VSS net_2089 net_2122 VSS nch_25od w=0.6u l=0.5u
M_162 net_2121 net_2122 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2123 net_2115 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2124 net_2118 net_2123 VSS nch_25od w=10u l=0.5u
M_165 net_2125 net_2118 net_2114 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2089 net_2121 VSS nch_25od w=5u l=0.5u
M_167 net_2091 net_2118 net_2085 VSS nch_25od w=30u l=0.5u
M_168 net_2126 net_2118 net_2124 VSS nch_25od w=10u l=0.5u
M_169 net_2085 net_2095 net_2126 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2089 net_2122 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2124 net_2118 net_2091 net_2071 pch_25od w=26u l=0.415u
M_172 net_2125 net_2124 net_2114 net_2071 pch_25od w=26u l=0.415u
M_173 VDD net_2089 net_2121 VDD pch_25od w=5u l=0.415u
M_174 net_2071 net_2124 VDDPST net_2071 pch_25od w=24u l=0.415u
M_175 net_2071 net_2118 net_2091 net_2071 pch_25od w=24u l=0.415u
M_176 net_2125 net_2118 net_2091 net_2071 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDDWDGZ
.SUBCKT PDIDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2127 net_2127 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_14 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_15 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_16 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_17 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_18 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_19 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_20 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_21 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_22 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_23 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_24 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_25 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_26 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_27 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
X_28 net_2128 net_2128 rppolywo w=0.4u l=1.3u m=1
M_29 net_2129 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2130 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2131 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2132 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2133 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2134 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2135 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2136 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2137 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2138 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2139 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_40 net_2140 net_2127 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_2141 net_2129 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2141 net_2130 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2141 net_2131 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2141 net_2132 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2141 net_2133 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2141 net_2134 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2141 net_2135 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2141 net_2136 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2141 net_2137 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2141 net_2138 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2141 net_2139 VSS nch_25od w=33u l=0.5u
M_52 PAD net_2141 net_2140 VSS nch_25od w=33u l=0.5u
M_53 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_54 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_55 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_56 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_57 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_58 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_59 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_60 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_61 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_62 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_63 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_64 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_65 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_66 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_67 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_68 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_69 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_70 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_71 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_72 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_73 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_74 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_75 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_76 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_77 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_78 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_79 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_80 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_81 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_82 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_83 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_84 PAD net_2128 VDDPST net_2128 pch_25od w=16.5u l=0.415u
M_85 VSS net_2142 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2128 net_2128 net_2128 net_2128 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2143 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_2144 net_2145 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2146 net_2145 net_2144 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2146 net_2145 net_2147 VDDPST pch_25od w=5u l=0.415u
M_93 net_2147 net_2148 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2149 net_2150 net_2151 VDDPST pch_25od w=20u l=0.415u
M_95 net_2149 net_2152 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2151 net_2152 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2150 net_2151 VSS nch_25od w=15u l=0.5u
M_98 net_2153 net_2154 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2155 net_2156 net_2157 VSS nch_25od w=10u l=0.5u
M_100 VSS net_2158 net_2159 VSS nch_25od w=10u l=0.5u
M_101 net_2160 net_2156 net_2161 VSS nch_25od w=10u l=0.5u
M_102 net_2159 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2159 net_2153 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2159 net_2153 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_2158 net_2161 VSS nch w=10u l=0.09u
M_106 net_2155 net_2154 VSS VSS nch w=10u l=0.09u
M_107 net_2160 net_2158 net_2159 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2153 net_2154 net_2157 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2162 net_2163 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2164 net_2156 net_2165 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2166 net_2167 VSS nch_25od w=10u l=0.5u
M_112 net_2168 net_2156 net_2169 VSS nch_25od w=10u l=0.5u
M_113 net_2167 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2167 net_2162 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2167 net_2162 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2166 net_2169 VSS nch w=10u l=0.09u
M_117 net_2164 net_2163 VSS VSS nch w=10u l=0.09u
M_118 net_2168 net_2166 net_2167 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2162 net_2163 net_2165 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2170 net_2171 VDDPST pch_25od w=40u l=0.415u
M_121 net_2171 net_2172 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2173 net_2170 net_2171 VSS nch_25od w=20u l=0.5u
M_123 net_2173 net_2172 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2166 net_2158 VSS nch w=3u l=0.1u
M_125 net_2166 net_2158 VDD VDD pch w=4u l=0.1u
M_126 net_2158 net_2166 net_2166 VDD pch w=4u l=0.1u
M_127 net_2142 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2143 net_2174 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2142 net_2166 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2142 net_2143 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2143 net_2142 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2156 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2156 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2148 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2127 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2175 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2141 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2166 ndio area=4p
D_139 VSS net_2166 ndio area=4p
D_140 VSS net_2158 ndio area=4p
M_141 net_2176 net_2153 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2176 net_2153 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2172 net_2162 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2172 net_2162 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2150 net_2159 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2150 net_2159 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2170 net_2176 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2170 net_2176 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2152 net_2167 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2152 net_2167 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2154 net_2158 VSS VSS nch w=3u l=0.09u
M_152 net_2154 net_2158 VDD VDD pch w=7.5u l=0.09u
M_153 net_2163 net_2166 VSS VSS nch w=3u l=0.09u
M_154 net_2163 net_2166 VDD VDD pch w=7.5u l=0.09u
M_155 net_2174 net_2166 VSS VSS nch w=3u l=0.09u
M_156 net_2174 net_2166 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2177 C VSS nch w=20u l=0.09u
M_158 VSS net_2178 net_2177 VSS nch w=10u l=0.09u
M_159 VDD net_2177 C VDD pch w=30u l=0.09u
M_160 VDD net_2178 net_2177 VDD pch w=10u l=0.09u
M_161 VSS net_2146 net_2179 VSS nch_25od w=0.6u l=0.5u
M_162 net_2178 net_2179 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2180 net_2172 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2181 net_2175 net_2180 VSS nch_25od w=10u l=0.5u
M_165 net_2182 net_2175 net_2171 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2146 net_2178 VSS nch_25od w=5u l=0.5u
M_167 net_2148 net_2175 net_2145 VSS nch_25od w=30u l=0.5u
M_168 net_2183 net_2175 net_2181 VSS nch_25od w=10u l=0.5u
M_169 net_2145 net_2152 net_2183 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2146 net_2179 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2181 net_2175 net_2148 net_2128 pch_25od w=26u l=0.415u
M_172 net_2182 net_2181 net_2171 net_2128 pch_25od w=26u l=0.415u
M_173 VDD net_2146 net_2178 VDD pch_25od w=5u l=0.415u
M_174 net_2128 net_2181 VDDPST net_2128 pch_25od w=24u l=0.415u
M_175 net_2128 net_2175 net_2148 net_2128 pch_25od w=24u l=0.415u
M_176 net_2182 net_2175 net_2148 net_2128 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDIDGZ
.SUBCKT PDISDGZ C PAD
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2184 net_2184 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_14 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_15 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_16 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_17 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_18 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_19 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_20 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_21 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_22 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_23 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_24 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_25 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_26 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_27 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
X_28 net_2185 net_2185 rppolywo w=0.4u l=1.3u m=1
M_29 net_2186 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2187 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2188 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2189 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2190 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2191 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2192 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2193 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2194 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2195 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2196 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_40 net_2197 net_2184 VSS VSS nch_25od w=33u l=0.5u
M_41 PAD net_2198 net_2186 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2198 net_2187 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2198 net_2188 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2198 net_2189 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2198 net_2190 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2198 net_2191 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2198 net_2192 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2198 net_2193 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2198 net_2194 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2198 net_2195 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2198 net_2196 VSS nch_25od w=33u l=0.5u
M_52 PAD net_2198 net_2197 VSS nch_25od w=33u l=0.5u
M_53 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_54 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_55 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_56 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_57 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_58 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_59 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_60 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_61 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_62 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_63 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_64 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_65 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_66 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_67 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_68 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_69 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_70 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_71 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_72 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_73 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_74 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_75 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_76 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_77 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_78 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_79 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_80 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_81 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_82 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_83 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_84 PAD net_2185 VDDPST net_2185 pch_25od w=16.5u l=0.415u
M_85 VSS net_2199 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2185 net_2185 net_2185 net_2185 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2200 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_2201 net_2202 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_2201 net_2203 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2202 net_2203 net_2201 VSS nch_25od w=5u l=0.5u
M_91 net_2204 net_2202 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2202 net_2203 net_2204 VDDPST pch_25od w=5u l=0.415u
M_93 net_2204 net_2205 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2206 net_2207 net_2208 VDDPST pch_25od w=20u l=0.415u
M_95 net_2206 net_2209 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2208 net_2209 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2207 net_2208 VSS nch_25od w=15u l=0.5u
M_98 net_2210 net_2211 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2212 net_2213 net_2214 VSS nch_25od w=10u l=0.5u
M_100 VSS net_2215 net_2216 VSS nch_25od w=10u l=0.5u
M_101 net_2217 net_2213 net_2218 VSS nch_25od w=10u l=0.5u
M_102 net_2216 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2216 net_2210 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2216 net_2210 VDDPST pch_25od w=3.5u l=1u
M_105 VSS net_2215 net_2218 VSS nch w=10u l=0.09u
M_106 net_2212 net_2211 VSS VSS nch w=10u l=0.09u
M_107 net_2217 net_2215 net_2216 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2210 net_2211 net_2214 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2219 net_2220 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2221 net_2213 net_2222 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2223 net_2224 VSS nch_25od w=10u l=0.5u
M_112 net_2225 net_2213 net_2226 VSS nch_25od w=10u l=0.5u
M_113 net_2224 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2224 net_2219 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2224 net_2219 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2223 net_2226 VSS nch w=10u l=0.09u
M_117 net_2221 net_2220 VSS VSS nch w=10u l=0.09u
M_118 net_2225 net_2223 net_2224 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2219 net_2220 net_2222 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2227 net_2228 VDDPST pch_25od w=40u l=0.415u
M_121 net_2228 net_2229 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2230 net_2227 net_2228 VSS nch_25od w=20u l=0.5u
M_123 net_2230 net_2229 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2223 net_2215 VSS nch w=3u l=0.1u
M_125 net_2223 net_2215 VDD VDD pch w=4u l=0.1u
M_126 net_2215 net_2223 net_2223 VDD pch w=4u l=0.1u
M_127 net_2199 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2200 net_2231 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2199 net_2223 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2199 net_2200 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2200 net_2199 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2213 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2213 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2205 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2184 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2232 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2198 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2223 ndio area=4p
D_139 VSS net_2223 ndio area=4p
D_140 VSS net_2215 ndio area=4p
M_141 net_2233 net_2210 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2233 net_2210 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2229 net_2219 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2229 net_2219 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2207 net_2216 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2207 net_2216 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2227 net_2233 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2227 net_2233 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2209 net_2224 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2209 net_2224 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2211 net_2215 VSS VSS nch w=3u l=0.09u
M_152 net_2211 net_2215 VDD VDD pch w=7.5u l=0.09u
M_153 net_2220 net_2223 VSS VSS nch w=3u l=0.09u
M_154 net_2220 net_2223 VDD VDD pch w=7.5u l=0.09u
M_155 net_2231 net_2223 VSS VSS nch w=3u l=0.09u
M_156 net_2231 net_2223 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2234 C VSS nch w=20u l=0.09u
M_158 VSS net_2235 net_2234 VSS nch w=10u l=0.09u
M_159 VDD net_2234 C VDD pch w=30u l=0.09u
M_160 VDD net_2235 net_2234 VDD pch w=10u l=0.09u
M_161 VSS net_2202 net_2236 VSS nch_25od w=0.6u l=0.5u
M_162 net_2235 net_2236 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2237 net_2229 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2238 net_2232 net_2237 VSS nch_25od w=10u l=0.5u
M_165 net_2239 net_2232 net_2228 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2202 net_2235 VSS nch_25od w=5u l=0.5u
M_167 net_2205 net_2232 net_2203 VSS nch_25od w=30u l=0.5u
M_168 net_2240 net_2232 net_2238 VSS nch_25od w=10u l=0.5u
M_169 net_2203 net_2209 net_2240 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2202 net_2236 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2238 net_2232 net_2205 net_2185 pch_25od w=26u l=0.415u
M_172 net_2239 net_2238 net_2228 net_2185 pch_25od w=26u l=0.415u
M_173 VDD net_2202 net_2235 VDD pch_25od w=5u l=0.415u
M_174 net_2185 net_2238 VDDPST net_2185 pch_25od w=24u l=0.415u
M_175 net_2185 net_2232 net_2205 net_2185 pch_25od w=24u l=0.415u
M_176 net_2239 net_2232 net_2205 net_2185 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDISDGZ
.SUBCKT PDO02CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2242 net_2242 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2242 net_2242 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2241 net_2241 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_14 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_15 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_16 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_17 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_18 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_19 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_20 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_21 net_2244 net_2244 rppolywo w=0.4u l=1.3u m=1
X_22 net_2244 net_2244 rppolywo w=0.4u l=1.3u m=1
X_23 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_24 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_25 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_26 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_27 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
X_28 net_2243 net_2243 rppolywo w=0.4u l=1.3u m=1
M_29 net_2245 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2246 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2247 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2248 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2249 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2250 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2251 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2252 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2253 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2254 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_39 net_2255 net_2241 VSS VSS nch_25od w=33u l=0.5u
M_40 PAD net_2256 net_2245 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2256 net_2246 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2256 net_2247 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2256 net_2248 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2256 net_2249 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2256 net_2250 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2256 net_2251 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2256 net_2252 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2256 net_2253 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2256 net_2254 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2256 net_2255 VSS nch_25od w=33u l=0.5u
M_51 PAD net_2256 net_2257 VSS nch_25od w=33u l=0.5u
M_52 net_2257 net_2242 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_54 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_55 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_56 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_57 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_58 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_59 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_60 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_61 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_62 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_63 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_64 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_65 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_66 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_67 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_68 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_69 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_70 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_71 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_72 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_73 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_74 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_75 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_76 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_77 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_78 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_79 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_80 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_81 PAD net_2243 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_82 PAD net_2244 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_83 PAD net_2244 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_84 PAD net_2244 VDDPST net_2243 pch_25od w=16.5u l=0.415u
M_85 VSS net_2258 VSS VSS nch_25od w=0.5u l=3u
M_86 net_2243 net_2243 net_2243 net_2243 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_2259 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_2260 net_2260 VSS nch_25od w=2.1u l=0.5u
M_89 net_2261 net_2262 VSS VSS nch_25od w=5u l=0.5u
M_90 net_2263 net_2262 net_2261 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_2260 net_2262 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_2263 net_2262 net_2264 VDDPST pch_25od w=5u l=0.415u
M_93 net_2264 net_2265 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_2266 net_2267 net_2242 VDDPST pch_25od w=20u l=0.415u
M_95 net_2266 net_2268 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_2242 net_2268 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_2267 net_2242 VSS nch_25od w=15u l=0.5u
M_98 net_2269 net_2270 VSS VSS nch_25od w=10u l=0.5u
M_99 net_2271 net_2272 net_2273 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_2274 VSS nch_25od w=10u l=0.5u
M_101 net_2275 net_2272 net_2276 VSS nch_25od w=10u l=0.5u
M_102 net_2274 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_2274 net_2269 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_2274 net_2269 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_2276 VSS nch w=10u l=0.09u
M_106 net_2271 net_2270 VSS VSS nch w=10u l=0.09u
M_107 net_2275 I net_2274 VSS nch_na25 w=5.5u l=1.32u
M_108 net_2269 net_2270 net_2273 VSS nch_na25 w=5.5u l=1.32u
M_109 net_2277 net_2278 VSS VSS nch_25od w=10u l=0.5u
M_110 net_2279 net_2272 net_2280 VSS nch_25od w=10u l=0.5u
M_111 VSS net_2281 net_2282 VSS nch_25od w=10u l=0.5u
M_112 net_2283 net_2272 net_2284 VSS nch_25od w=10u l=0.5u
M_113 net_2282 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_2282 net_2277 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_2282 net_2277 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_2281 net_2284 VSS nch w=10u l=0.09u
M_117 net_2279 net_2278 VSS VSS nch w=10u l=0.09u
M_118 net_2283 net_2281 net_2282 VSS nch_na25 w=5.5u l=1.32u
M_119 net_2277 net_2278 net_2280 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_2285 net_2286 VDDPST pch_25od w=40u l=0.415u
M_121 net_2286 net_2287 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_2288 net_2285 net_2286 VSS nch_25od w=20u l=0.5u
M_123 net_2288 net_2287 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_2289 net_2281 VSS nch w=3u l=0.1u
M_125 net_2289 net_2281 VDD VDD pch w=4u l=0.1u
M_126 net_2281 net_2289 net_2289 VDD pch w=4u l=0.1u
M_127 net_2258 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_2259 net_2290 VSS VSS nch_25od w=20u l=0.5u
M_129 net_2258 net_2289 VSS VSS nch_25od w=20u l=0.5u
M_130 net_2258 net_2259 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_2259 net_2258 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_2272 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_2272 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_2265 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_2241 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_2291 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_2256 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_2289 ndio area=4p
D_139 VSS net_2281 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_2292 net_2269 VSS VSS nch_25od w=2u l=0.5u
M_142 net_2292 net_2269 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_2287 net_2277 VSS VSS nch_25od w=3u l=0.5u
M_144 net_2287 net_2277 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_2267 net_2274 VSS VSS nch_25od w=7u l=0.5u
M_146 net_2267 net_2274 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_2285 net_2292 VSS VSS nch_25od w=10u l=0.5u
M_148 net_2285 net_2292 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_2268 net_2282 VSS VSS nch_25od w=3u l=0.5u
M_150 net_2268 net_2282 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_2270 I VSS VSS nch w=3u l=0.09u
M_152 net_2270 I VDD VDD pch w=7.5u l=0.09u
M_153 net_2278 net_2281 VSS VSS nch w=3u l=0.09u
M_154 net_2278 net_2281 VDD VDD pch w=7.5u l=0.09u
M_155 net_2290 net_2289 VSS VSS nch w=3u l=0.09u
M_156 net_2290 net_2289 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_2293 net_2294 VSS nch w=20u l=0.09u
M_158 VSS net_2295 net_2293 VSS nch w=10u l=0.09u
M_159 VDD net_2293 net_2294 VDD pch w=30u l=0.09u
M_160 VDD net_2295 net_2293 VDD pch w=10u l=0.09u
M_161 VSS net_2263 net_2296 VSS nch_25od w=0.6u l=0.5u
M_162 net_2295 net_2296 VDD VSS nch_25od w=5u l=0.5u
M_163 net_2297 net_2287 VSS VSS nch_25od w=10u l=0.5u
M_164 net_2298 net_2291 net_2297 VSS nch_25od w=10u l=0.5u
M_165 net_2244 net_2291 net_2286 VSS nch_25od w=30u l=0.5u
M_166 VSS net_2263 net_2295 VSS nch_25od w=5u l=0.5u
M_167 net_2265 net_2291 net_2299 VSS nch_25od w=30u l=0.5u
M_168 net_2300 net_2291 net_2298 VSS nch_25od w=10u l=0.5u
M_169 net_2299 net_2268 net_2300 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_2263 net_2296 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_2298 net_2291 net_2265 net_2243 pch_25od w=26u l=0.415u
M_172 net_2244 net_2298 net_2286 net_2243 pch_25od w=26u l=0.415u
M_173 VDD net_2263 net_2295 VDD pch_25od w=5u l=0.415u
M_174 net_2243 net_2298 VDDPST net_2243 pch_25od w=24u l=0.415u
M_175 net_2243 net_2291 net_2265 net_2243 pch_25od w=24u l=0.415u
M_176 net_2244 net_2291 net_2265 net_2243 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PDO02CDG
.SUBCKT PDO04CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_2 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_3 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_4 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_5 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_6 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_7 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_8 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_9 net_2302 net_2302 rnpolywo w=0.4u l=2.93u m=1
X_10 net_2302 net_2302 rnpolywo w=0.4u l=2.93u m=1
X_11 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_12 net_2301 net_2301 rnpolywo w=0.4u l=2.93u m=1
X_13 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_14 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_15 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_16 net_2304 net_2304 rppolywo w=0.4u l=1.3u m=1
X_17 net_2304 net_2304 rppolywo w=0.4u l=1.3u m=1
X_18 net_2304 net_2304 rppolywo w=0.4u l=1.3u m=1
X_19 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_20 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_21 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_22 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_23 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_24 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_25 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_26 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_27 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
X_28 net_2303 net_2303 rppolywo w=0.4u l=1.3u m=1
M_29 net_2305 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_30 net_2306 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_31 net_2307 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_32 net_2308 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_33 net_2309 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_34 net_2310 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_35 net_2311 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_36 net_2312 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_37 net_2313 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_38 net_2314 net_2301 VSS VSS nch_25od w=33u l=0.5u
M_39 PAD net_2315 net_2305 VSS nch_25od w=33u l=0.5u
M_40 PAD net_2315 net_2306 VSS nch_25od w=33u l=0.5u
M_41 PAD net_2315 net_2307 VSS nch_25od w=33u l=0.5u
M_42 PAD net_2315 net_2308 VSS nch_25od w=33u l=0.5u
M_43 PAD net_2315 net_2309 VSS nch_25od w=33u l=0.5u
M_44 PAD net_2315 net_2310 VSS nch_25od w=33u l=0.5u
M_45 PAD net_2315 net_2311 VSS nch_25od w=33u l=0.5u
M_46 PAD net_2315 net_2312 VSS nch_25od w=33u l=0.5u
M_47 PAD net_2315 net_2313 VSS nch_25od w=33u l=0.5u
M_48 PAD net_2315 net_2314 VSS nch_25od w=33u l=0.5u
M_49 PAD net_2315 net_2316 VSS nch_25od w=33u l=0.5u
M_50 PAD net_2315 net_2317 VSS nch_25od w=33u l=0.5u
M_51 net_2316 net_2302 VSS VSS nch_25od w=33u l=0.5u
M_52 net_2317 net_2302 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_54 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_55 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_56 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_57 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_58 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_59 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_60 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_61 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_62 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_63 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_64 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_65 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_66 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_67 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_68 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_69 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_70 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_71 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_72 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_73 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_74 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_75 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_76 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_77 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
M_78 PAD net_2303 VDDPST net_2303 pch_25od w=16.5u l=0.415u
