M_53 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_54 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_55 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_56 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_57 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_58 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_59 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_60 PAD net_4660 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_61 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_62 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_63 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_64 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_65 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_66 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_67 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_68 PAD net_4661 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_69 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_70 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_71 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_72 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_73 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_74 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_75 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_76 PAD net_4663 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_77 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_78 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_79 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_80 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_81 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_82 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_83 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_84 PAD net_4662 VDDPST net_4663 pch_25od w=16.5u l=0.415u
M_85 VSS net_4678 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4663 net_4663 net_4663 net_4663 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4679 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_4680 net_4681 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_4680 net_4682 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4681 net_4682 net_4680 VSS nch_25od w=5u l=0.5u
M_91 net_4683 net_4681 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4681 net_4682 net_4683 VDDPST pch_25od w=5u l=0.415u
M_93 net_4683 net_4684 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4685 net_4686 net_4654 VDDPST pch_25od w=20u l=0.415u
M_95 net_4685 net_4687 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4654 net_4687 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4686 net_4654 VSS nch_25od w=15u l=0.5u
M_98 net_4688 net_4689 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4690 net_4691 net_4692 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4693 VSS nch_25od w=10u l=0.5u
M_101 net_4694 net_4691 net_4695 VSS nch_25od w=10u l=0.5u
M_102 net_4693 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4693 net_4688 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4693 net_4688 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4695 VSS nch w=10u l=0.09u
M_106 net_4690 net_4689 VSS VSS nch w=10u l=0.09u
M_107 net_4694 I net_4693 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4688 net_4689 net_4692 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4696 net_4697 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4698 net_4691 net_4699 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4700 VSS nch_25od w=10u l=0.5u
M_112 net_4701 net_4691 net_4702 VSS nch_25od w=10u l=0.5u
M_113 net_4700 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4700 net_4696 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4700 net_4696 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4702 VSS nch w=10u l=0.09u
M_117 net_4698 net_4697 VSS VSS nch w=10u l=0.09u
M_118 net_4701 OEN net_4700 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4696 net_4697 net_4699 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4703 net_4704 VDDPST pch_25od w=40u l=0.415u
M_121 net_4704 net_4705 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4706 net_4703 net_4704 VSS nch_25od w=20u l=0.5u
M_123 net_4706 net_4705 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4707 net_4708 VSS nch w=3u l=0.1u
M_125 net_4707 net_4708 VDD VDD pch w=4u l=0.1u
M_126 net_4708 net_4707 net_4707 VDD pch w=4u l=0.1u
M_127 net_4678 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4679 net_4709 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4678 net_4707 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4678 net_4679 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4679 net_4678 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4691 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4691 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4684 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4656 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4710 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4665 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4707 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4711 net_4688 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4711 net_4688 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4705 net_4696 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4705 net_4696 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4686 net_4693 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4686 net_4693 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4703 net_4711 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4703 net_4711 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4687 net_4700 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4687 net_4700 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4689 I VSS VSS nch w=3u l=0.09u
M_152 net_4689 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4697 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4697 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4709 net_4707 VSS VSS nch w=3u l=0.09u
M_156 net_4709 net_4707 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4712 C VSS nch w=20u l=0.09u
M_158 VSS net_4713 net_4712 VSS nch w=10u l=0.09u
M_159 VDD net_4712 C VDD pch w=30u l=0.09u
M_160 VDD net_4713 net_4712 VDD pch w=10u l=0.09u
M_161 VSS net_4681 net_4714 VSS nch_25od w=0.6u l=0.5u
M_162 net_4713 net_4714 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4715 net_4705 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4716 net_4710 net_4715 VSS nch_25od w=10u l=0.5u
M_165 net_4664 net_4710 net_4704 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4681 net_4713 VSS nch_25od w=5u l=0.5u
M_167 net_4684 net_4710 net_4682 VSS nch_25od w=30u l=0.5u
M_168 net_4717 net_4710 net_4716 VSS nch_25od w=10u l=0.5u
M_169 net_4682 net_4687 net_4717 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4681 net_4714 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4716 net_4710 net_4684 net_4663 pch_25od w=26u l=0.415u
M_172 net_4664 net_4716 net_4704 net_4663 pch_25od w=26u l=0.415u
M_173 VDD net_4681 net_4713 VDD pch_25od w=5u l=0.415u
M_174 net_4663 net_4716 VDDPST net_4663 pch_25od w=24u l=0.415u
M_175 net_4663 net_4710 net_4684 net_4663 pch_25od w=24u l=0.415u
M_176 net_4664 net_4710 net_4684 net_4663 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB16SDGZ
.SUBCKT PRB24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4718 net_4719 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4720 net_4721 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4722 net_4723 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4719 net_4719 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4724 net_4724 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4720 net_4720 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4724 net_4720 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4721 net_4721 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4721 net_4721 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4721 net_4721 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4719 net_4724 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4723 net_4718 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_14 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_15 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_16 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_17 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_18 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_19 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_20 net_4725 net_4725 rppolywo w=0.4u l=1.3u m=1
X_21 net_4726 net_4726 rppolywo w=0.4u l=1.3u m=1
X_22 net_4726 net_4726 rppolywo w=0.4u l=1.3u m=1
X_23 net_4727 net_4727 rppolywo w=0.4u l=1.3u m=1
X_24 net_4727 net_4727 rppolywo w=0.4u l=1.3u m=1
X_25 net_4727 net_4727 rppolywo w=0.4u l=1.3u m=1
X_26 net_4728 net_4725 rppolywo w=0.4u l=1.3u m=1
X_27 net_4725 net_4726 rppolywo w=0.4u l=1.3u m=1
X_28 net_4726 net_4727 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4729 net_4730 VSS nch_25od w=33u l=0.5u
M_30 net_4731 net_4724 VSS VSS nch_25od w=33u l=0.5u
M_31 net_4732 net_4724 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_4729 net_4731 VSS nch_25od w=33u l=0.5u
M_33 PAD net_4729 net_4732 VSS nch_25od w=33u l=0.5u
M_34 net_4733 net_4721 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4734 net_4721 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4735 net_4721 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4730 net_4723 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_4729 net_4733 VSS nch_25od w=33u l=0.5u
M_39 PAD net_4729 net_4734 VSS nch_25od w=33u l=0.5u
M_40 PAD net_4729 net_4735 VSS nch_25od w=33u l=0.5u
M_41 PAD net_4729 net_4736 VSS nch_25od w=33u l=0.5u
M_42 PAD net_4729 net_4737 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4729 net_4738 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4729 net_4739 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4729 net_4740 VSS nch_25od w=33u l=0.5u
M_46 net_4739 net_4719 VSS VSS nch_25od w=33u l=0.5u
M_47 net_4740 net_4719 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_4729 net_4741 VSS nch_25od w=33u l=0.5u
M_49 net_4736 net_4720 VSS VSS nch_25od w=33u l=0.5u
M_50 net_4737 net_4720 VSS VSS nch_25od w=33u l=0.5u
M_51 net_4738 net_4720 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4741 net_4718 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_54 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_55 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_56 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_57 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_58 PAD net_4726 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_59 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_60 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_61 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_62 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_63 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_64 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_65 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_66 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_67 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_68 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_69 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_70 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_71 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_72 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_73 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_74 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_75 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_76 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_77 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_78 PAD net_4725 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_79 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_80 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_81 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_82 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_83 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_84 PAD net_4727 VDDPST net_4742 pch_25od w=16.5u l=0.415u
M_85 VSS net_4743 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4742 net_4742 net_4742 net_4742 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4744 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4745 net_4746 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4747 net_4746 net_4745 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4747 net_4746 net_4748 VDDPST pch_25od w=5u l=0.415u
M_93 net_4748 net_4749 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4750 net_4751 net_4722 VDDPST pch_25od w=20u l=0.415u
M_95 net_4750 net_4752 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4722 net_4752 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4751 net_4722 VSS nch_25od w=15u l=0.5u
M_98 net_4753 net_4754 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4755 net_4756 net_4757 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4758 VSS nch_25od w=10u l=0.5u
M_101 net_4759 net_4756 net_4760 VSS nch_25od w=10u l=0.5u
M_102 net_4758 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4758 net_4753 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4758 net_4753 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4760 VSS nch w=10u l=0.09u
M_106 net_4755 net_4754 VSS VSS nch w=10u l=0.09u
M_107 net_4759 I net_4758 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4753 net_4754 net_4757 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4761 net_4762 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4763 net_4756 net_4764 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4765 VSS nch_25od w=10u l=0.5u
M_112 net_4766 net_4756 net_4767 VSS nch_25od w=10u l=0.5u
M_113 net_4765 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4765 net_4761 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4765 net_4761 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4767 VSS nch w=10u l=0.09u
M_117 net_4763 net_4762 VSS VSS nch w=10u l=0.09u
M_118 net_4766 OEN net_4765 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4761 net_4762 net_4764 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4768 net_4769 VDDPST pch_25od w=40u l=0.415u
M_121 net_4769 net_4770 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4771 net_4768 net_4769 VSS nch_25od w=20u l=0.5u
M_123 net_4771 net_4770 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4772 net_4773 VSS nch w=3u l=0.1u
M_125 net_4772 net_4773 VDD VDD pch w=4u l=0.1u
M_126 net_4773 net_4772 net_4772 VDD pch w=4u l=0.1u
M_127 net_4743 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4744 net_4774 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4743 net_4772 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4743 net_4744 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4744 net_4743 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4756 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4756 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4749 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4775 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4776 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4729 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4772 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4777 net_4753 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4777 net_4753 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4770 net_4761 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4770 net_4761 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4751 net_4758 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4751 net_4758 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4768 net_4777 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4768 net_4777 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4752 net_4765 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4752 net_4765 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4754 I VSS VSS nch w=3u l=0.09u
M_152 net_4754 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4762 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4762 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4774 net_4772 VSS VSS nch w=3u l=0.09u
M_156 net_4774 net_4772 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4778 C VSS nch w=20u l=0.09u
M_158 VSS net_4779 net_4778 VSS nch w=10u l=0.09u
M_159 VDD net_4778 C VDD pch w=30u l=0.09u
M_160 VDD net_4779 net_4778 VDD pch w=10u l=0.09u
M_161 VSS net_4747 net_4780 VSS nch_25od w=0.6u l=0.5u
M_162 net_4779 net_4780 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4781 net_4770 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4782 net_4776 net_4781 VSS nch_25od w=10u l=0.5u
M_165 net_4728 net_4776 net_4769 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4747 net_4779 VSS nch_25od w=5u l=0.5u
M_167 net_4749 net_4776 net_4746 VSS nch_25od w=30u l=0.5u
M_168 net_4783 net_4776 net_4782 VSS nch_25od w=10u l=0.5u
M_169 net_4746 net_4752 net_4783 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4747 net_4780 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4782 net_4776 net_4749 net_4742 pch_25od w=26u l=0.415u
M_172 net_4728 net_4782 net_4769 net_4742 pch_25od w=26u l=0.415u
M_173 VDD net_4747 net_4779 VDD pch_25od w=5u l=0.415u
M_174 net_4742 net_4782 VDDPST net_4742 pch_25od w=24u l=0.415u
M_175 net_4742 net_4776 net_4749 net_4742 pch_25od w=24u l=0.415u
M_176 net_4728 net_4776 net_4749 net_4742 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB24DGZ
.SUBCKT PRB24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4784 net_4785 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4786 net_4787 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4788 net_4789 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4785 net_4785 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4790 net_4790 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4786 net_4786 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4790 net_4786 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4787 net_4787 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4787 net_4787 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4787 net_4787 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4785 net_4790 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4789 net_4784 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_14 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_15 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_16 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_17 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_18 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_19 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_20 net_4791 net_4791 rppolywo w=0.4u l=1.3u m=1
X_21 net_4792 net_4792 rppolywo w=0.4u l=1.3u m=1
X_22 net_4792 net_4792 rppolywo w=0.4u l=1.3u m=1
X_23 net_4793 net_4793 rppolywo w=0.4u l=1.3u m=1
X_24 net_4793 net_4793 rppolywo w=0.4u l=1.3u m=1
X_25 net_4793 net_4793 rppolywo w=0.4u l=1.3u m=1
X_26 net_4794 net_4791 rppolywo w=0.4u l=1.3u m=1
X_27 net_4791 net_4792 rppolywo w=0.4u l=1.3u m=1
X_28 net_4792 net_4793 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4795 net_4796 VSS nch_25od w=33u l=0.5u
M_30 net_4797 net_4790 VSS VSS nch_25od w=33u l=0.5u
M_31 net_4798 net_4790 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_4795 net_4797 VSS nch_25od w=33u l=0.5u
M_33 PAD net_4795 net_4798 VSS nch_25od w=33u l=0.5u
M_34 net_4799 net_4787 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4800 net_4787 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4801 net_4787 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4796 net_4789 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_4795 net_4799 VSS nch_25od w=33u l=0.5u
M_39 PAD net_4795 net_4800 VSS nch_25od w=33u l=0.5u
M_40 PAD net_4795 net_4801 VSS nch_25od w=33u l=0.5u
M_41 PAD net_4795 net_4802 VSS nch_25od w=33u l=0.5u
M_42 PAD net_4795 net_4803 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4795 net_4804 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4795 net_4805 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4795 net_4806 VSS nch_25od w=33u l=0.5u
M_46 net_4805 net_4785 VSS VSS nch_25od w=33u l=0.5u
M_47 net_4806 net_4785 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_4795 net_4807 VSS nch_25od w=33u l=0.5u
M_49 net_4802 net_4786 VSS VSS nch_25od w=33u l=0.5u
M_50 net_4803 net_4786 VSS VSS nch_25od w=33u l=0.5u
M_51 net_4804 net_4786 VSS VSS nch_25od w=33u l=0.5u
M_52 net_4807 net_4784 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_54 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_55 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_56 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_57 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_58 PAD net_4792 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_59 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_60 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_61 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_62 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_63 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_64 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_65 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_66 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_67 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_68 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_69 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_70 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_71 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_72 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_73 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_74 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_75 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_76 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_77 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_78 PAD net_4791 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_79 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_80 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_81 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_82 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_83 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_84 PAD net_4793 VDDPST net_4808 pch_25od w=16.5u l=0.415u
M_85 VSS net_4809 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4808 net_4808 net_4808 net_4808 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4810 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_4811 net_4812 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_4811 net_4813 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4812 net_4813 net_4811 VSS nch_25od w=5u l=0.5u
M_91 net_4814 net_4812 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4812 net_4813 net_4814 VDDPST pch_25od w=5u l=0.415u
M_93 net_4814 net_4815 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4816 net_4817 net_4788 VDDPST pch_25od w=20u l=0.415u
M_95 net_4816 net_4818 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4788 net_4818 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4817 net_4788 VSS nch_25od w=15u l=0.5u
M_98 net_4819 net_4820 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4821 net_4822 net_4823 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4824 VSS nch_25od w=10u l=0.5u
M_101 net_4825 net_4822 net_4826 VSS nch_25od w=10u l=0.5u
M_102 net_4824 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4824 net_4819 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4824 net_4819 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4826 VSS nch w=10u l=0.09u
M_106 net_4821 net_4820 VSS VSS nch w=10u l=0.09u
M_107 net_4825 I net_4824 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4819 net_4820 net_4823 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4827 net_4828 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4829 net_4822 net_4830 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4831 VSS nch_25od w=10u l=0.5u
M_112 net_4832 net_4822 net_4833 VSS nch_25od w=10u l=0.5u
M_113 net_4831 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4831 net_4827 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4831 net_4827 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4833 VSS nch w=10u l=0.09u
M_117 net_4829 net_4828 VSS VSS nch w=10u l=0.09u
M_118 net_4832 OEN net_4831 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4827 net_4828 net_4830 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4834 net_4835 VDDPST pch_25od w=40u l=0.415u
M_121 net_4835 net_4836 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4837 net_4834 net_4835 VSS nch_25od w=20u l=0.5u
M_123 net_4837 net_4836 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4838 net_4839 VSS nch w=3u l=0.1u
M_125 net_4838 net_4839 VDD VDD pch w=4u l=0.1u
M_126 net_4839 net_4838 net_4838 VDD pch w=4u l=0.1u
M_127 net_4809 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4810 net_4840 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4809 net_4838 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4809 net_4810 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4810 net_4809 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4822 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4822 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4815 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4841 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4842 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4795 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4838 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4843 net_4819 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4843 net_4819 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4836 net_4827 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4836 net_4827 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4817 net_4824 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4817 net_4824 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4834 net_4843 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4834 net_4843 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4818 net_4831 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4818 net_4831 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4820 I VSS VSS nch w=3u l=0.09u
M_152 net_4820 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4828 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4828 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4840 net_4838 VSS VSS nch w=3u l=0.09u
M_156 net_4840 net_4838 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4844 C VSS nch w=20u l=0.09u
M_158 VSS net_4845 net_4844 VSS nch w=10u l=0.09u
M_159 VDD net_4844 C VDD pch w=30u l=0.09u
M_160 VDD net_4845 net_4844 VDD pch w=10u l=0.09u
M_161 VSS net_4812 net_4846 VSS nch_25od w=0.6u l=0.5u
M_162 net_4845 net_4846 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4847 net_4836 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4848 net_4842 net_4847 VSS nch_25od w=10u l=0.5u
M_165 net_4794 net_4842 net_4835 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4812 net_4845 VSS nch_25od w=5u l=0.5u
M_167 net_4815 net_4842 net_4813 VSS nch_25od w=30u l=0.5u
M_168 net_4849 net_4842 net_4848 VSS nch_25od w=10u l=0.5u
M_169 net_4813 net_4818 net_4849 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4812 net_4846 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4848 net_4842 net_4815 net_4808 pch_25od w=26u l=0.415u
M_172 net_4794 net_4848 net_4835 net_4808 pch_25od w=26u l=0.415u
M_173 VDD net_4812 net_4845 VDD pch_25od w=5u l=0.415u
M_174 net_4808 net_4848 VDDPST net_4808 pch_25od w=24u l=0.415u
M_175 net_4808 net_4842 net_4815 net_4808 pch_25od w=24u l=0.415u
M_176 net_4794 net_4842 net_4815 net_4808 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRB24SDGZ
.SUBCKT PRCUT
*PGATE NGATE
.ENDS PRCUT
.SUBCKT PRD08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4850 net_4851 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4852 net_4852 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4851 net_4853 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4854 net_4850 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4855 net_4854 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4856 net_4856 rppolywo w=0.4u l=1.3u m=1
X_14 net_4857 net_4857 rppolywo w=0.4u l=1.3u m=1
X_15 net_4858 net_4858 rppolywo w=0.4u l=1.3u m=1
X_16 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_17 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_18 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_19 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_20 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_21 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_22 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_23 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_24 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_25 net_4859 net_4859 rppolywo w=0.4u l=1.3u m=1
X_26 net_4860 net_4856 rppolywo w=0.4u l=1.3u m=1
X_27 net_4856 net_4857 rppolywo w=0.4u l=1.3u m=1
X_28 net_4857 net_4858 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4861 net_4862 VSS nch_25od w=33u l=0.5u
M_30 PAD net_4861 net_4863 VSS nch_25od w=33u l=0.5u
M_31 net_4863 net_4854 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4862 net_4851 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4864 net_4850 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4865 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4866 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4867 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4868 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4869 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4870 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4871 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4872 net_4852 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_4861 net_4865 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4861 net_4866 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4861 net_4867 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4861 net_4868 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4861 net_4869 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4861 net_4870 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4861 net_4871 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4861 net_4872 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4861 net_4864 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4861 net_4873 VSS nch_25od w=33u l=0.5u
M_52 net_4873 net_4853 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4856 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_54 PAD net_4856 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_55 PAD net_4856 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_56 PAD net_4856 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_57 PAD net_4857 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_58 PAD net_4857 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_59 PAD net_4857 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_60 PAD net_4857 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_61 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_62 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_63 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_64 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_65 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_66 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_67 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_68 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_69 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_70 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_71 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_72 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_73 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_74 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_75 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_76 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_77 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_78 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_79 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_80 PAD net_4859 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_81 PAD net_4858 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_82 PAD net_4858 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_83 PAD net_4858 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_84 PAD net_4858 VDDPST net_4859 pch_25od w=16.5u l=0.415u
M_85 net_4874 net_4875 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4859 net_4859 net_4859 net_4859 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4876 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_4877 net_4874 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4878 net_4874 net_4877 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4878 net_4874 net_4879 VDDPST pch_25od w=5u l=0.415u
M_93 net_4879 net_4880 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4881 net_4882 net_4855 VDDPST pch_25od w=20u l=0.415u
M_95 net_4881 net_4883 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4855 net_4883 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4882 net_4855 VSS nch_25od w=15u l=0.5u
M_98 net_4884 net_4885 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4886 net_4887 net_4888 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4889 VSS nch_25od w=10u l=0.5u
M_101 net_4890 net_4887 net_4891 VSS nch_25od w=10u l=0.5u
M_102 net_4889 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4889 net_4884 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4889 net_4884 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4891 VSS nch w=10u l=0.09u
M_106 net_4886 net_4885 VSS VSS nch w=10u l=0.09u
M_107 net_4890 I net_4889 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4884 net_4885 net_4888 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4892 net_4893 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4894 net_4887 net_4895 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4896 VSS nch_25od w=10u l=0.5u
M_112 net_4897 net_4887 net_4898 VSS nch_25od w=10u l=0.5u
M_113 net_4896 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4896 net_4892 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4896 net_4892 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4898 VSS nch w=10u l=0.09u
M_117 net_4894 net_4893 VSS VSS nch w=10u l=0.09u
M_118 net_4897 OEN net_4896 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4892 net_4893 net_4895 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4899 net_4900 VDDPST pch_25od w=40u l=0.415u
M_121 net_4900 net_4901 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4902 net_4899 net_4900 VSS nch_25od w=20u l=0.5u
M_123 net_4902 net_4901 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4903 net_4904 VSS nch w=3u l=0.1u
M_125 net_4903 net_4904 VDD VDD pch w=4u l=0.1u
M_126 net_4904 net_4903 net_4903 VDD pch w=4u l=0.1u
M_127 net_4875 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4876 net_4905 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4875 net_4904 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4875 net_4876 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4876 net_4875 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4887 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4887 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4880 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4852 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4906 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4861 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4904 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4907 net_4884 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4907 net_4884 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4901 net_4892 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4901 net_4892 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4882 net_4889 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4882 net_4889 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4899 net_4907 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4899 net_4907 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4883 net_4896 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4883 net_4896 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4885 I VSS VSS nch w=3u l=0.09u
M_152 net_4885 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4893 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4893 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4905 net_4904 VSS VSS nch w=3u l=0.09u
M_156 net_4905 net_4904 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4908 C VSS nch w=20u l=0.09u
M_158 VSS net_4909 net_4908 VSS nch w=10u l=0.09u
M_159 VDD net_4908 C VDD pch w=30u l=0.09u
M_160 VDD net_4909 net_4908 VDD pch w=10u l=0.09u
M_161 VSS net_4878 net_4910 VSS nch_25od w=0.6u l=0.5u
M_162 net_4909 net_4910 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4911 net_4901 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4912 net_4906 net_4911 VSS nch_25od w=10u l=0.5u
M_165 net_4860 net_4906 net_4900 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4878 net_4909 VSS nch_25od w=5u l=0.5u
M_167 net_4880 net_4906 net_4874 VSS nch_25od w=30u l=0.5u
M_168 net_4913 net_4906 net_4912 VSS nch_25od w=10u l=0.5u
M_169 net_4874 net_4883 net_4913 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4878 net_4910 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4912 net_4906 net_4880 net_4859 pch_25od w=26u l=0.415u
M_172 net_4860 net_4912 net_4900 net_4859 pch_25od w=26u l=0.415u
M_173 VDD net_4878 net_4909 VDD pch_25od w=5u l=0.415u
M_174 net_4859 net_4912 VDDPST net_4859 pch_25od w=24u l=0.415u
M_175 net_4859 net_4906 net_4880 net_4859 pch_25od w=24u l=0.415u
M_176 net_4860 net_4906 net_4880 net_4859 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD08DGZ
.SUBCKT PRD08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4914 net_4915 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4916 net_4916 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4915 net_4917 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4918 net_4914 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4919 net_4918 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4920 net_4920 rppolywo w=0.4u l=1.3u m=1
X_14 net_4921 net_4921 rppolywo w=0.4u l=1.3u m=1
X_15 net_4922 net_4922 rppolywo w=0.4u l=1.3u m=1
X_16 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_17 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_18 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_19 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_20 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_21 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_22 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_23 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_24 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_25 net_4923 net_4923 rppolywo w=0.4u l=1.3u m=1
X_26 net_4924 net_4920 rppolywo w=0.4u l=1.3u m=1
X_27 net_4920 net_4921 rppolywo w=0.4u l=1.3u m=1
X_28 net_4921 net_4922 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4925 net_4926 VSS nch_25od w=33u l=0.5u
M_30 PAD net_4925 net_4927 VSS nch_25od w=33u l=0.5u
M_31 net_4927 net_4918 VSS VSS nch_25od w=33u l=0.5u
M_32 net_4926 net_4915 VSS VSS nch_25od w=33u l=0.5u
M_33 net_4928 net_4914 VSS VSS nch_25od w=33u l=0.5u
M_34 net_4929 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_35 net_4930 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_36 net_4931 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_37 net_4932 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4933 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4934 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4935 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4936 net_4916 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_4925 net_4929 VSS nch_25od w=33u l=0.5u
M_43 PAD net_4925 net_4930 VSS nch_25od w=33u l=0.5u
M_44 PAD net_4925 net_4931 VSS nch_25od w=33u l=0.5u
M_45 PAD net_4925 net_4932 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4925 net_4933 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4925 net_4934 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4925 net_4935 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4925 net_4936 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4925 net_4928 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4925 net_4937 VSS nch_25od w=33u l=0.5u
M_52 net_4937 net_4917 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4920 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_54 PAD net_4920 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_55 PAD net_4920 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_56 PAD net_4920 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_57 PAD net_4921 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_58 PAD net_4921 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_59 PAD net_4921 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_60 PAD net_4921 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_61 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_62 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_63 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_64 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_65 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_66 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_67 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_68 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_69 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_70 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_71 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_72 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_73 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_74 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_75 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_76 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_77 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_78 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_79 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_80 PAD net_4923 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_81 PAD net_4922 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_82 PAD net_4922 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_83 PAD net_4922 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_84 PAD net_4922 VDDPST net_4923 pch_25od w=16.5u l=0.415u
M_85 net_4938 net_4939 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4923 net_4923 net_4923 net_4923 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_4940 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_4941 net_4942 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_4941 net_4938 VSS VSS nch_25od w=5u l=0.5u
M_90 net_4942 net_4938 net_4941 VSS nch_25od w=5u l=0.5u
M_91 net_4943 net_4942 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_4942 net_4938 net_4943 VDDPST pch_25od w=5u l=0.415u
M_93 net_4943 net_4944 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_4945 net_4946 net_4919 VDDPST pch_25od w=20u l=0.415u
M_95 net_4945 net_4947 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4919 net_4947 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_4946 net_4919 VSS nch_25od w=15u l=0.5u
M_98 net_4948 net_4949 VSS VSS nch_25od w=10u l=0.5u
M_99 net_4950 net_4951 net_4952 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_4953 VSS nch_25od w=10u l=0.5u
M_101 net_4954 net_4951 net_4955 VSS nch_25od w=10u l=0.5u
M_102 net_4953 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_4953 net_4948 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_4953 net_4948 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_4955 VSS nch w=10u l=0.09u
M_106 net_4950 net_4949 VSS VSS nch w=10u l=0.09u
M_107 net_4954 I net_4953 VSS nch_na25 w=5.5u l=1.32u
M_108 net_4948 net_4949 net_4952 VSS nch_na25 w=5.5u l=1.32u
M_109 net_4956 net_4957 VSS VSS nch_25od w=10u l=0.5u
M_110 net_4958 net_4951 net_4959 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_4960 VSS nch_25od w=10u l=0.5u
M_112 net_4961 net_4951 net_4962 VSS nch_25od w=10u l=0.5u
M_113 net_4960 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_4960 net_4956 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_4960 net_4956 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_4962 VSS nch w=10u l=0.09u
M_117 net_4958 net_4957 VSS VSS nch w=10u l=0.09u
M_118 net_4961 OEN net_4960 VSS nch_na25 w=5.5u l=1.32u
M_119 net_4956 net_4957 net_4959 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_4963 net_4964 VDDPST pch_25od w=40u l=0.415u
M_121 net_4964 net_4965 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_4966 net_4963 net_4964 VSS nch_25od w=20u l=0.5u
M_123 net_4966 net_4965 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_4967 net_4968 VSS nch w=3u l=0.1u
M_125 net_4967 net_4968 VDD VDD pch w=4u l=0.1u
M_126 net_4968 net_4967 net_4967 VDD pch w=4u l=0.1u
M_127 net_4939 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_4940 net_4969 VSS VSS nch_25od w=20u l=0.5u
M_129 net_4939 net_4968 VSS VSS nch_25od w=20u l=0.5u
M_130 net_4939 net_4940 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_4940 net_4939 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_4951 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_4951 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_4944 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4916 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_4970 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4925 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_4968 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_4971 net_4948 VSS VSS nch_25od w=2u l=0.5u
M_142 net_4971 net_4948 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_4965 net_4956 VSS VSS nch_25od w=3u l=0.5u
M_144 net_4965 net_4956 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_4946 net_4953 VSS VSS nch_25od w=7u l=0.5u
M_146 net_4946 net_4953 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_4963 net_4971 VSS VSS nch_25od w=10u l=0.5u
M_148 net_4963 net_4971 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_4947 net_4960 VSS VSS nch_25od w=3u l=0.5u
M_150 net_4947 net_4960 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_4949 I VSS VSS nch w=3u l=0.09u
M_152 net_4949 I VDD VDD pch w=7.5u l=0.09u
M_153 net_4957 OEN VSS VSS nch w=3u l=0.09u
M_154 net_4957 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_4969 net_4968 VSS VSS nch w=3u l=0.09u
M_156 net_4969 net_4968 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_4972 C VSS nch w=20u l=0.09u
M_158 VSS net_4973 net_4972 VSS nch w=10u l=0.09u
M_159 VDD net_4972 C VDD pch w=30u l=0.09u
M_160 VDD net_4973 net_4972 VDD pch w=10u l=0.09u
M_161 VSS net_4942 net_4974 VSS nch_25od w=0.6u l=0.5u
M_162 net_4973 net_4974 VDD VSS nch_25od w=5u l=0.5u
M_163 net_4975 net_4965 VSS VSS nch_25od w=10u l=0.5u
M_164 net_4976 net_4970 net_4975 VSS nch_25od w=10u l=0.5u
M_165 net_4924 net_4970 net_4964 VSS nch_25od w=30u l=0.5u
M_166 VSS net_4942 net_4973 VSS nch_25od w=5u l=0.5u
M_167 net_4944 net_4970 net_4938 VSS nch_25od w=30u l=0.5u
M_168 net_4977 net_4970 net_4976 VSS nch_25od w=10u l=0.5u
M_169 net_4938 net_4947 net_4977 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_4942 net_4974 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_4976 net_4970 net_4944 net_4923 pch_25od w=26u l=0.415u
M_172 net_4924 net_4976 net_4964 net_4923 pch_25od w=26u l=0.415u
M_173 VDD net_4942 net_4973 VDD pch_25od w=5u l=0.415u
M_174 net_4923 net_4976 VDDPST net_4923 pch_25od w=24u l=0.415u
M_175 net_4923 net_4970 net_4944 net_4923 pch_25od w=24u l=0.415u
M_176 net_4924 net_4970 net_4944 net_4923 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD08SDGZ
.SUBCKT PRD12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_4978 net_4979 rnpolywo w=0.4u l=2.93u m=1
X_2 net_4980 net_4981 rnpolywo w=0.4u l=2.93u m=1
X_3 net_4982 net_4983 rnpolywo w=0.4u l=2.93u m=1
X_4 net_4983 net_4984 rnpolywo w=0.4u l=2.93u m=1
X_5 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_6 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_7 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_8 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_9 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_10 net_4985 net_4985 rnpolywo w=0.4u l=2.93u m=1
X_11 net_4979 net_4982 rnpolywo w=0.4u l=2.93u m=1
X_12 net_4981 net_4978 rnpolywo w=0.4u l=2.93u m=1
X_13 net_4986 net_4986 rppolywo w=0.4u l=1.3u m=1
X_14 net_4986 net_4986 rppolywo w=0.4u l=1.3u m=1
X_15 net_4987 net_4987 rppolywo w=0.4u l=1.3u m=1
X_16 net_4987 net_4987 rppolywo w=0.4u l=1.3u m=1
X_17 net_4988 net_4988 rppolywo w=0.4u l=1.3u m=1
X_18 net_4988 net_4988 rppolywo w=0.4u l=1.3u m=1
X_19 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_20 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_21 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_22 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_23 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_24 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_25 net_4989 net_4989 rppolywo w=0.4u l=1.3u m=1
X_26 net_4990 net_4986 rppolywo w=0.4u l=1.3u m=1
X_27 net_4986 net_4987 rppolywo w=0.4u l=1.3u m=1
X_28 net_4987 net_4988 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_4991 net_4992 VSS nch_25od w=33u l=0.5u
M_30 net_4993 net_4982 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_4991 net_4993 VSS nch_25od w=33u l=0.5u
M_32 net_4992 net_4981 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_4991 net_4994 VSS nch_25od w=33u l=0.5u
M_34 PAD net_4991 net_4995 VSS nch_25od w=33u l=0.5u
M_35 net_4995 net_4979 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_4991 net_4996 VSS nch_25od w=33u l=0.5u
M_37 net_4994 net_4983 VSS VSS nch_25od w=33u l=0.5u
M_38 net_4996 net_4978 VSS VSS nch_25od w=33u l=0.5u
M_39 net_4997 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_40 net_4998 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_41 net_4999 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5000 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5001 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5002 net_4985 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_4991 net_4997 VSS nch_25od w=33u l=0.5u
M_46 PAD net_4991 net_4998 VSS nch_25od w=33u l=0.5u
M_47 PAD net_4991 net_4999 VSS nch_25od w=33u l=0.5u
M_48 PAD net_4991 net_5000 VSS nch_25od w=33u l=0.5u
M_49 PAD net_4991 net_5001 VSS nch_25od w=33u l=0.5u
M_50 PAD net_4991 net_5002 VSS nch_25od w=33u l=0.5u
M_51 PAD net_4991 net_5003 VSS nch_25od w=33u l=0.5u
M_52 net_5003 net_4984 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_54 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_55 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_56 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_57 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_58 PAD net_4986 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_59 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_60 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_61 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_62 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_63 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_64 PAD net_4987 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_65 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_66 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_67 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_68 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_69 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_70 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_71 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_72 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_73 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_74 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_75 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_76 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_77 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_78 PAD net_4989 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_79 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_80 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_81 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_82 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_83 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_84 PAD net_4988 VDDPST net_4989 pch_25od w=16.5u l=0.415u
M_85 net_5004 net_5005 VSS VSS nch_25od w=0.5u l=3u
M_86 net_4989 net_4989 net_4989 net_4989 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5006 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5007 net_5004 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5008 net_5004 net_5007 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5008 net_5004 net_5009 VDDPST pch_25od w=5u l=0.415u
M_93 net_5009 net_5010 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5011 net_5012 net_4980 VDDPST pch_25od w=20u l=0.415u
M_95 net_5011 net_5013 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_4980 net_5013 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5012 net_4980 VSS nch_25od w=15u l=0.5u
M_98 net_5014 net_5015 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5016 net_5017 net_5018 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5019 VSS nch_25od w=10u l=0.5u
M_101 net_5020 net_5017 net_5021 VSS nch_25od w=10u l=0.5u
M_102 net_5019 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5019 net_5014 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5019 net_5014 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5021 VSS nch w=10u l=0.09u
M_106 net_5016 net_5015 VSS VSS nch w=10u l=0.09u
M_107 net_5020 I net_5019 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5014 net_5015 net_5018 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5022 net_5023 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5024 net_5017 net_5025 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5026 VSS nch_25od w=10u l=0.5u
M_112 net_5027 net_5017 net_5028 VSS nch_25od w=10u l=0.5u
M_113 net_5026 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5026 net_5022 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5026 net_5022 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5028 VSS nch w=10u l=0.09u
M_117 net_5024 net_5023 VSS VSS nch w=10u l=0.09u
M_118 net_5027 OEN net_5026 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5022 net_5023 net_5025 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5029 net_5030 VDDPST pch_25od w=40u l=0.415u
M_121 net_5030 net_5031 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5032 net_5029 net_5030 VSS nch_25od w=20u l=0.5u
M_123 net_5032 net_5031 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5033 net_5034 VSS nch w=3u l=0.1u
M_125 net_5033 net_5034 VDD VDD pch w=4u l=0.1u
M_126 net_5034 net_5033 net_5033 VDD pch w=4u l=0.1u
M_127 net_5005 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5006 net_5035 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5005 net_5034 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5005 net_5006 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5006 net_5005 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5017 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5017 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5010 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_4985 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5036 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_4991 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5034 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5037 net_5014 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5037 net_5014 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5031 net_5022 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5031 net_5022 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5012 net_5019 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5012 net_5019 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5029 net_5037 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5029 net_5037 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5013 net_5026 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5013 net_5026 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5015 I VSS VSS nch w=3u l=0.09u
M_152 net_5015 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5023 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5023 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5035 net_5034 VSS VSS nch w=3u l=0.09u
M_156 net_5035 net_5034 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5038 C VSS nch w=20u l=0.09u
M_158 VSS net_5039 net_5038 VSS nch w=10u l=0.09u
M_159 VDD net_5038 C VDD pch w=30u l=0.09u
M_160 VDD net_5039 net_5038 VDD pch w=10u l=0.09u
M_161 VSS net_5008 net_5040 VSS nch_25od w=0.6u l=0.5u
M_162 net_5039 net_5040 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5041 net_5031 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5042 net_5036 net_5041 VSS nch_25od w=10u l=0.5u
M_165 net_4990 net_5036 net_5030 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5008 net_5039 VSS nch_25od w=5u l=0.5u
M_167 net_5010 net_5036 net_5004 VSS nch_25od w=30u l=0.5u
M_168 net_5043 net_5036 net_5042 VSS nch_25od w=10u l=0.5u
M_169 net_5004 net_5013 net_5043 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5008 net_5040 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5042 net_5036 net_5010 net_4989 pch_25od w=26u l=0.415u
M_172 net_4990 net_5042 net_5030 net_4989 pch_25od w=26u l=0.415u
M_173 VDD net_5008 net_5039 VDD pch_25od w=5u l=0.415u
M_174 net_4989 net_5042 VDDPST net_4989 pch_25od w=24u l=0.415u
M_175 net_4989 net_5036 net_5010 net_4989 pch_25od w=24u l=0.415u
M_176 net_4990 net_5036 net_5010 net_4989 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD12DGZ
.SUBCKT PRD12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5044 net_5045 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5046 net_5047 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5048 net_5049 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5049 net_5050 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5051 net_5051 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5045 net_5048 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5047 net_5044 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5052 net_5052 rppolywo w=0.4u l=1.3u m=1
X_14 net_5052 net_5052 rppolywo w=0.4u l=1.3u m=1
X_15 net_5053 net_5053 rppolywo w=0.4u l=1.3u m=1
X_16 net_5053 net_5053 rppolywo w=0.4u l=1.3u m=1
X_17 net_5054 net_5054 rppolywo w=0.4u l=1.3u m=1
X_18 net_5054 net_5054 rppolywo w=0.4u l=1.3u m=1
X_19 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_20 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_21 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_22 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_23 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_24 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_25 net_5055 net_5055 rppolywo w=0.4u l=1.3u m=1
X_26 net_5056 net_5052 rppolywo w=0.4u l=1.3u m=1
X_27 net_5052 net_5053 rppolywo w=0.4u l=1.3u m=1
X_28 net_5053 net_5054 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5057 net_5058 VSS nch_25od w=33u l=0.5u
M_30 net_5059 net_5048 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5057 net_5059 VSS nch_25od w=33u l=0.5u
M_32 net_5058 net_5047 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5057 net_5060 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5057 net_5061 VSS nch_25od w=33u l=0.5u
M_35 net_5061 net_5045 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_5057 net_5062 VSS nch_25od w=33u l=0.5u
M_37 net_5060 net_5049 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5062 net_5044 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5063 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5064 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5065 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5066 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5067 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5068 net_5051 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5057 net_5063 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5057 net_5064 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5057 net_5065 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5057 net_5066 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5057 net_5067 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5057 net_5068 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5057 net_5069 VSS nch_25od w=33u l=0.5u
M_52 net_5069 net_5050 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_54 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_55 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_56 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_57 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_58 PAD net_5052 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_59 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_60 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_61 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_62 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_63 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_64 PAD net_5053 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_65 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_66 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_67 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_68 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_69 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_70 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_71 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_72 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_73 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_74 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_75 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_76 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_77 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_78 PAD net_5055 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_79 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_80 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_81 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_82 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_83 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_84 PAD net_5054 VDDPST net_5055 pch_25od w=16.5u l=0.415u
M_85 net_5070 net_5071 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5055 net_5055 net_5055 net_5055 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5072 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_5073 net_5074 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_5073 net_5070 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5074 net_5070 net_5073 VSS nch_25od w=5u l=0.5u
M_91 net_5075 net_5074 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5074 net_5070 net_5075 VDDPST pch_25od w=5u l=0.415u
M_93 net_5075 net_5076 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5077 net_5078 net_5046 VDDPST pch_25od w=20u l=0.415u
M_95 net_5077 net_5079 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5046 net_5079 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5078 net_5046 VSS nch_25od w=15u l=0.5u
M_98 net_5080 net_5081 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5082 net_5083 net_5084 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5085 VSS nch_25od w=10u l=0.5u
M_101 net_5086 net_5083 net_5087 VSS nch_25od w=10u l=0.5u
M_102 net_5085 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5085 net_5080 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5085 net_5080 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5087 VSS nch w=10u l=0.09u
M_106 net_5082 net_5081 VSS VSS nch w=10u l=0.09u
M_107 net_5086 I net_5085 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5080 net_5081 net_5084 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5088 net_5089 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5090 net_5083 net_5091 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5092 VSS nch_25od w=10u l=0.5u
M_112 net_5093 net_5083 net_5094 VSS nch_25od w=10u l=0.5u
M_113 net_5092 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5092 net_5088 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5092 net_5088 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5094 VSS nch w=10u l=0.09u
M_117 net_5090 net_5089 VSS VSS nch w=10u l=0.09u
M_118 net_5093 OEN net_5092 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5088 net_5089 net_5091 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5095 net_5096 VDDPST pch_25od w=40u l=0.415u
M_121 net_5096 net_5097 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5098 net_5095 net_5096 VSS nch_25od w=20u l=0.5u
M_123 net_5098 net_5097 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5099 net_5100 VSS nch w=3u l=0.1u
M_125 net_5099 net_5100 VDD VDD pch w=4u l=0.1u
M_126 net_5100 net_5099 net_5099 VDD pch w=4u l=0.1u
M_127 net_5071 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5072 net_5101 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5071 net_5100 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5071 net_5072 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5072 net_5071 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5083 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5083 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5076 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5051 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5102 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5057 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5100 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5103 net_5080 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5103 net_5080 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5097 net_5088 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5097 net_5088 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5078 net_5085 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5078 net_5085 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5095 net_5103 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5095 net_5103 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5079 net_5092 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5079 net_5092 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5081 I VSS VSS nch w=3u l=0.09u
M_152 net_5081 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5089 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5089 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5101 net_5100 VSS VSS nch w=3u l=0.09u
M_156 net_5101 net_5100 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5104 C VSS nch w=20u l=0.09u
M_158 VSS net_5105 net_5104 VSS nch w=10u l=0.09u
M_159 VDD net_5104 C VDD pch w=30u l=0.09u
M_160 VDD net_5105 net_5104 VDD pch w=10u l=0.09u
M_161 VSS net_5074 net_5106 VSS nch_25od w=0.6u l=0.5u
M_162 net_5105 net_5106 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5107 net_5097 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5108 net_5102 net_5107 VSS nch_25od w=10u l=0.5u
M_165 net_5056 net_5102 net_5096 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5074 net_5105 VSS nch_25od w=5u l=0.5u
M_167 net_5076 net_5102 net_5070 VSS nch_25od w=30u l=0.5u
M_168 net_5109 net_5102 net_5108 VSS nch_25od w=10u l=0.5u
M_169 net_5070 net_5079 net_5109 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5074 net_5106 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5108 net_5102 net_5076 net_5055 pch_25od w=26u l=0.415u
M_172 net_5056 net_5108 net_5096 net_5055 pch_25od w=26u l=0.415u
M_173 VDD net_5074 net_5105 VDD pch_25od w=5u l=0.415u
M_174 net_5055 net_5108 VDDPST net_5055 pch_25od w=24u l=0.415u
M_175 net_5055 net_5102 net_5076 net_5055 pch_25od w=24u l=0.415u
M_176 net_5056 net_5102 net_5076 net_5055 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD12SDGZ
.SUBCKT PRD16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5110 net_5111 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5112 net_5113 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5114 net_5114 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5114 net_5114 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5114 net_5114 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5114 net_5114 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5115 net_5116 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5116 net_5117 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5117 net_5117 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5116 net_5116 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5111 net_5115 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5113 net_5110 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5118 net_5118 rppolywo w=0.4u l=1.3u m=1
X_14 net_5118 net_5118 rppolywo w=0.4u l=1.3u m=1
X_15 net_5118 net_5118 rppolywo w=0.4u l=1.3u m=1
X_16 net_5119 net_5119 rppolywo w=0.4u l=1.3u m=1
X_17 net_5119 net_5119 rppolywo w=0.4u l=1.3u m=1
X_18 net_5119 net_5119 rppolywo w=0.4u l=1.3u m=1
X_19 net_5120 net_5120 rppolywo w=0.4u l=1.3u m=1
X_20 net_5120 net_5120 rppolywo w=0.4u l=1.3u m=1
X_21 net_5120 net_5120 rppolywo w=0.4u l=1.3u m=1
X_22 net_5121 net_5121 rppolywo w=0.4u l=1.3u m=1
X_23 net_5121 net_5121 rppolywo w=0.4u l=1.3u m=1
X_24 net_5121 net_5121 rppolywo w=0.4u l=1.3u m=1
X_25 net_5121 net_5121 rppolywo w=0.4u l=1.3u m=1
X_26 net_5122 net_5119 rppolywo w=0.4u l=1.3u m=1
X_27 net_5119 net_5118 rppolywo w=0.4u l=1.3u m=1
X_28 net_5118 net_5120 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5123 net_5124 VSS nch_25od w=33u l=0.5u
M_30 net_5125 net_5115 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5123 net_5125 VSS nch_25od w=33u l=0.5u
M_32 net_5124 net_5113 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5123 net_5126 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5123 net_5127 VSS nch_25od w=33u l=0.5u
M_35 PAD net_5123 net_5128 VSS nch_25od w=33u l=0.5u
M_36 net_5128 net_5111 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_5123 net_5129 VSS nch_25od w=33u l=0.5u
M_38 net_5126 net_5116 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5127 net_5116 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5129 net_5110 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5130 net_5114 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5131 net_5114 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5132 net_5114 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5133 net_5114 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5123 net_5130 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5123 net_5131 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5123 net_5132 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5123 net_5133 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5123 net_5134 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5123 net_5135 VSS nch_25od w=33u l=0.5u
M_51 net_5134 net_5117 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5135 net_5117 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_54 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_55 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_56 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_57 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_58 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_59 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_60 PAD net_5118 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_61 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_62 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_63 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_64 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_65 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_66 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_67 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_68 PAD net_5119 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_69 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_70 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_71 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_72 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_73 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_74 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_75 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_76 PAD net_5121 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_77 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_78 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_79 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_80 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_81 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_82 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_83 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_84 PAD net_5120 VDDPST net_5121 pch_25od w=16.5u l=0.415u
M_85 net_5136 net_5137 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5121 net_5121 net_5121 net_5121 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5138 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5139 net_5136 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5140 net_5136 net_5139 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5140 net_5136 net_5141 VDDPST pch_25od w=5u l=0.415u
M_93 net_5141 net_5142 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5143 net_5144 net_5112 VDDPST pch_25od w=20u l=0.415u
M_95 net_5143 net_5145 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5112 net_5145 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5144 net_5112 VSS nch_25od w=15u l=0.5u
M_98 net_5146 net_5147 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5148 net_5149 net_5150 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5151 VSS nch_25od w=10u l=0.5u
M_101 net_5152 net_5149 net_5153 VSS nch_25od w=10u l=0.5u
M_102 net_5151 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5151 net_5146 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5151 net_5146 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5153 VSS nch w=10u l=0.09u
M_106 net_5148 net_5147 VSS VSS nch w=10u l=0.09u
M_107 net_5152 I net_5151 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5146 net_5147 net_5150 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5154 net_5155 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5156 net_5149 net_5157 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5158 VSS nch_25od w=10u l=0.5u
M_112 net_5159 net_5149 net_5160 VSS nch_25od w=10u l=0.5u
M_113 net_5158 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5158 net_5154 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5158 net_5154 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5160 VSS nch w=10u l=0.09u
M_117 net_5156 net_5155 VSS VSS nch w=10u l=0.09u
M_118 net_5159 OEN net_5158 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5154 net_5155 net_5157 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5161 net_5162 VDDPST pch_25od w=40u l=0.415u
M_121 net_5162 net_5163 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5164 net_5161 net_5162 VSS nch_25od w=20u l=0.5u
M_123 net_5164 net_5163 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5165 net_5166 VSS nch w=3u l=0.1u
M_125 net_5165 net_5166 VDD VDD pch w=4u l=0.1u
M_126 net_5166 net_5165 net_5165 VDD pch w=4u l=0.1u
M_127 net_5137 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5138 net_5167 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5137 net_5166 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5137 net_5138 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5138 net_5137 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5149 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5149 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5142 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5114 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5168 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5123 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5166 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5169 net_5146 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5169 net_5146 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5163 net_5154 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5163 net_5154 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5144 net_5151 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5144 net_5151 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5161 net_5169 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5161 net_5169 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5145 net_5158 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5145 net_5158 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5147 I VSS VSS nch w=3u l=0.09u
M_152 net_5147 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5155 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5155 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5167 net_5166 VSS VSS nch w=3u l=0.09u
M_156 net_5167 net_5166 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5170 C VSS nch w=20u l=0.09u
M_158 VSS net_5171 net_5170 VSS nch w=10u l=0.09u
M_159 VDD net_5170 C VDD pch w=30u l=0.09u
M_160 VDD net_5171 net_5170 VDD pch w=10u l=0.09u
M_161 VSS net_5140 net_5172 VSS nch_25od w=0.6u l=0.5u
M_162 net_5171 net_5172 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5173 net_5163 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5174 net_5168 net_5173 VSS nch_25od w=10u l=0.5u
M_165 net_5122 net_5168 net_5162 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5140 net_5171 VSS nch_25od w=5u l=0.5u
M_167 net_5142 net_5168 net_5136 VSS nch_25od w=30u l=0.5u
M_168 net_5175 net_5168 net_5174 VSS nch_25od w=10u l=0.5u
M_169 net_5136 net_5145 net_5175 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5140 net_5172 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5174 net_5168 net_5142 net_5121 pch_25od w=26u l=0.415u
M_172 net_5122 net_5174 net_5162 net_5121 pch_25od w=26u l=0.415u
M_173 VDD net_5140 net_5171 VDD pch_25od w=5u l=0.415u
M_174 net_5121 net_5174 VDDPST net_5121 pch_25od w=24u l=0.415u
M_175 net_5121 net_5168 net_5142 net_5121 pch_25od w=24u l=0.415u
M_176 net_5122 net_5168 net_5142 net_5121 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD16DGZ
.SUBCKT PRD16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5176 net_5177 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5178 net_5179 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5180 net_5180 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5180 net_5180 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5180 net_5180 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5180 net_5180 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5181 net_5182 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5182 net_5183 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5183 net_5183 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5182 net_5182 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5177 net_5181 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5179 net_5176 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5184 net_5184 rppolywo w=0.4u l=1.3u m=1
X_14 net_5184 net_5184 rppolywo w=0.4u l=1.3u m=1
X_15 net_5184 net_5184 rppolywo w=0.4u l=1.3u m=1
X_16 net_5185 net_5185 rppolywo w=0.4u l=1.3u m=1
X_17 net_5185 net_5185 rppolywo w=0.4u l=1.3u m=1
X_18 net_5185 net_5185 rppolywo w=0.4u l=1.3u m=1
X_19 net_5186 net_5186 rppolywo w=0.4u l=1.3u m=1
X_20 net_5186 net_5186 rppolywo w=0.4u l=1.3u m=1
X_21 net_5186 net_5186 rppolywo w=0.4u l=1.3u m=1
X_22 net_5187 net_5187 rppolywo w=0.4u l=1.3u m=1
X_23 net_5187 net_5187 rppolywo w=0.4u l=1.3u m=1
X_24 net_5187 net_5187 rppolywo w=0.4u l=1.3u m=1
X_25 net_5187 net_5187 rppolywo w=0.4u l=1.3u m=1
X_26 net_5188 net_5185 rppolywo w=0.4u l=1.3u m=1
X_27 net_5185 net_5184 rppolywo w=0.4u l=1.3u m=1
X_28 net_5184 net_5186 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5189 net_5190 VSS nch_25od w=33u l=0.5u
M_30 net_5191 net_5181 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5189 net_5191 VSS nch_25od w=33u l=0.5u
M_32 net_5190 net_5179 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5189 net_5192 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5189 net_5193 VSS nch_25od w=33u l=0.5u
M_35 PAD net_5189 net_5194 VSS nch_25od w=33u l=0.5u
M_36 net_5194 net_5177 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_5189 net_5195 VSS nch_25od w=33u l=0.5u
M_38 net_5192 net_5182 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5193 net_5182 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5195 net_5176 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5196 net_5180 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5197 net_5180 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5198 net_5180 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5199 net_5180 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5189 net_5196 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5189 net_5197 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5189 net_5198 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5189 net_5199 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5189 net_5200 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5189 net_5201 VSS nch_25od w=33u l=0.5u
M_51 net_5200 net_5183 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5201 net_5183 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_54 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_55 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_56 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_57 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_58 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_59 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_60 PAD net_5184 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_61 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_62 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_63 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_64 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_65 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_66 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_67 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_68 PAD net_5185 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_69 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_70 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_71 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_72 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_73 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_74 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_75 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_76 PAD net_5187 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_77 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_78 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_79 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_80 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_81 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_82 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_83 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_84 PAD net_5186 VDDPST net_5187 pch_25od w=16.5u l=0.415u
M_85 net_5202 net_5203 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5187 net_5187 net_5187 net_5187 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5204 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_5205 net_5206 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_5205 net_5202 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5206 net_5202 net_5205 VSS nch_25od w=5u l=0.5u
M_91 net_5207 net_5206 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5206 net_5202 net_5207 VDDPST pch_25od w=5u l=0.415u
M_93 net_5207 net_5208 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5209 net_5210 net_5178 VDDPST pch_25od w=20u l=0.415u
M_95 net_5209 net_5211 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5178 net_5211 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5210 net_5178 VSS nch_25od w=15u l=0.5u
M_98 net_5212 net_5213 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5214 net_5215 net_5216 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5217 VSS nch_25od w=10u l=0.5u
M_101 net_5218 net_5215 net_5219 VSS nch_25od w=10u l=0.5u
M_102 net_5217 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5217 net_5212 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5217 net_5212 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5219 VSS nch w=10u l=0.09u
M_106 net_5214 net_5213 VSS VSS nch w=10u l=0.09u
M_107 net_5218 I net_5217 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5212 net_5213 net_5216 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5220 net_5221 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5222 net_5215 net_5223 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5224 VSS nch_25od w=10u l=0.5u
M_112 net_5225 net_5215 net_5226 VSS nch_25od w=10u l=0.5u
M_113 net_5224 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5224 net_5220 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5224 net_5220 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5226 VSS nch w=10u l=0.09u
M_117 net_5222 net_5221 VSS VSS nch w=10u l=0.09u
M_118 net_5225 OEN net_5224 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5220 net_5221 net_5223 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5227 net_5228 VDDPST pch_25od w=40u l=0.415u
M_121 net_5228 net_5229 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5230 net_5227 net_5228 VSS nch_25od w=20u l=0.5u
M_123 net_5230 net_5229 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5231 net_5232 VSS nch w=3u l=0.1u
M_125 net_5231 net_5232 VDD VDD pch w=4u l=0.1u
M_126 net_5232 net_5231 net_5231 VDD pch w=4u l=0.1u
M_127 net_5203 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5204 net_5233 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5203 net_5232 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5203 net_5204 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5204 net_5203 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5215 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5215 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5208 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5180 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5234 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5189 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5232 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5235 net_5212 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5235 net_5212 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5229 net_5220 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5229 net_5220 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5210 net_5217 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5210 net_5217 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5227 net_5235 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5227 net_5235 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5211 net_5224 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5211 net_5224 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5213 I VSS VSS nch w=3u l=0.09u
M_152 net_5213 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5221 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5221 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5233 net_5232 VSS VSS nch w=3u l=0.09u
M_156 net_5233 net_5232 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5236 C VSS nch w=20u l=0.09u
M_158 VSS net_5237 net_5236 VSS nch w=10u l=0.09u
M_159 VDD net_5236 C VDD pch w=30u l=0.09u
M_160 VDD net_5237 net_5236 VDD pch w=10u l=0.09u
M_161 VSS net_5206 net_5238 VSS nch_25od w=0.6u l=0.5u
M_162 net_5237 net_5238 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5239 net_5229 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5240 net_5234 net_5239 VSS nch_25od w=10u l=0.5u
M_165 net_5188 net_5234 net_5228 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5206 net_5237 VSS nch_25od w=5u l=0.5u
M_167 net_5208 net_5234 net_5202 VSS nch_25od w=30u l=0.5u
M_168 net_5241 net_5234 net_5240 VSS nch_25od w=10u l=0.5u
M_169 net_5202 net_5211 net_5241 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5206 net_5238 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5240 net_5234 net_5208 net_5187 pch_25od w=26u l=0.415u
M_172 net_5188 net_5240 net_5228 net_5187 pch_25od w=26u l=0.415u
M_173 VDD net_5206 net_5237 VDD pch_25od w=5u l=0.415u
M_174 net_5187 net_5240 VDDPST net_5187 pch_25od w=24u l=0.415u
M_175 net_5187 net_5234 net_5208 net_5187 pch_25od w=24u l=0.415u
M_176 net_5188 net_5234 net_5208 net_5187 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD16SDGZ
.SUBCKT PRD24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5242 net_5243 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5244 net_5245 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5246 net_5247 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5243 net_5243 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5248 net_5248 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5244 net_5244 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5248 net_5244 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5245 net_5245 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5245 net_5245 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5245 net_5245 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5243 net_5248 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5247 net_5242 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_14 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_15 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_16 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_17 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_18 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_19 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_20 net_5249 net_5249 rppolywo w=0.4u l=1.3u m=1
X_21 net_5250 net_5250 rppolywo w=0.4u l=1.3u m=1
X_22 net_5250 net_5250 rppolywo w=0.4u l=1.3u m=1
X_23 net_5251 net_5251 rppolywo w=0.4u l=1.3u m=1
X_24 net_5251 net_5251 rppolywo w=0.4u l=1.3u m=1
X_25 net_5251 net_5251 rppolywo w=0.4u l=1.3u m=1
X_26 net_5252 net_5249 rppolywo w=0.4u l=1.3u m=1
X_27 net_5249 net_5250 rppolywo w=0.4u l=1.3u m=1
X_28 net_5250 net_5251 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5253 net_5254 VSS nch_25od w=33u l=0.5u
M_30 net_5255 net_5248 VSS VSS nch_25od w=33u l=0.5u
M_31 net_5256 net_5248 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_5253 net_5255 VSS nch_25od w=33u l=0.5u
M_33 PAD net_5253 net_5256 VSS nch_25od w=33u l=0.5u
M_34 net_5257 net_5245 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5258 net_5245 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5259 net_5245 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5254 net_5247 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_5253 net_5257 VSS nch_25od w=33u l=0.5u
M_39 PAD net_5253 net_5258 VSS nch_25od w=33u l=0.5u
M_40 PAD net_5253 net_5259 VSS nch_25od w=33u l=0.5u
M_41 PAD net_5253 net_5260 VSS nch_25od w=33u l=0.5u
M_42 PAD net_5253 net_5261 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5253 net_5262 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5253 net_5263 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5253 net_5264 VSS nch_25od w=33u l=0.5u
M_46 net_5263 net_5243 VSS VSS nch_25od w=33u l=0.5u
M_47 net_5264 net_5243 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_5253 net_5265 VSS nch_25od w=33u l=0.5u
M_49 net_5260 net_5244 VSS VSS nch_25od w=33u l=0.5u
M_50 net_5261 net_5244 VSS VSS nch_25od w=33u l=0.5u
M_51 net_5262 net_5244 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5265 net_5242 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_54 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_55 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_56 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_57 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_58 PAD net_5250 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_59 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_60 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_61 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_62 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_63 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_64 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_65 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_66 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_67 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_68 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_69 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_70 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_71 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_72 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_73 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_74 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_75 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_76 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_77 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_78 PAD net_5249 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_79 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_80 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_81 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_82 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_83 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_84 PAD net_5251 VDDPST net_5266 pch_25od w=16.5u l=0.415u
M_85 net_5267 net_5268 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5266 net_5266 net_5266 net_5266 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5269 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5270 net_5267 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5271 net_5267 net_5270 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5271 net_5267 net_5272 VDDPST pch_25od w=5u l=0.415u
M_93 net_5272 net_5273 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5274 net_5275 net_5246 VDDPST pch_25od w=20u l=0.415u
M_95 net_5274 net_5276 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5246 net_5276 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5275 net_5246 VSS nch_25od w=15u l=0.5u
M_98 net_5277 net_5278 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5279 net_5280 net_5281 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5282 VSS nch_25od w=10u l=0.5u
M_101 net_5283 net_5280 net_5284 VSS nch_25od w=10u l=0.5u
M_102 net_5282 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5282 net_5277 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5282 net_5277 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5284 VSS nch w=10u l=0.09u
M_106 net_5279 net_5278 VSS VSS nch w=10u l=0.09u
M_107 net_5283 I net_5282 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5277 net_5278 net_5281 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5285 net_5286 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5287 net_5280 net_5288 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5289 VSS nch_25od w=10u l=0.5u
M_112 net_5290 net_5280 net_5291 VSS nch_25od w=10u l=0.5u
M_113 net_5289 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5289 net_5285 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5289 net_5285 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5291 VSS nch w=10u l=0.09u
M_117 net_5287 net_5286 VSS VSS nch w=10u l=0.09u
M_118 net_5290 OEN net_5289 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5285 net_5286 net_5288 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5292 net_5293 VDDPST pch_25od w=40u l=0.415u
M_121 net_5293 net_5294 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5295 net_5292 net_5293 VSS nch_25od w=20u l=0.5u
M_123 net_5295 net_5294 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5296 net_5297 VSS nch w=3u l=0.1u
M_125 net_5296 net_5297 VDD VDD pch w=4u l=0.1u
M_126 net_5297 net_5296 net_5296 VDD pch w=4u l=0.1u
M_127 net_5268 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5269 net_5298 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5268 net_5297 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5268 net_5269 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5269 net_5268 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5280 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5280 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5273 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5299 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5300 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5253 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5297 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5301 net_5277 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5301 net_5277 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5294 net_5285 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5294 net_5285 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5275 net_5282 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5275 net_5282 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5292 net_5301 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5292 net_5301 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5276 net_5289 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5276 net_5289 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5278 I VSS VSS nch w=3u l=0.09u
M_152 net_5278 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5286 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5286 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5298 net_5297 VSS VSS nch w=3u l=0.09u
M_156 net_5298 net_5297 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5302 C VSS nch w=20u l=0.09u
M_158 VSS net_5303 net_5302 VSS nch w=10u l=0.09u
M_159 VDD net_5302 C VDD pch w=30u l=0.09u
M_160 VDD net_5303 net_5302 VDD pch w=10u l=0.09u
M_161 VSS net_5271 net_5304 VSS nch_25od w=0.6u l=0.5u
M_162 net_5303 net_5304 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5305 net_5294 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5306 net_5300 net_5305 VSS nch_25od w=10u l=0.5u
M_165 net_5252 net_5300 net_5293 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5271 net_5303 VSS nch_25od w=5u l=0.5u
M_167 net_5273 net_5300 net_5267 VSS nch_25od w=30u l=0.5u
M_168 net_5307 net_5300 net_5306 VSS nch_25od w=10u l=0.5u
M_169 net_5267 net_5276 net_5307 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5271 net_5304 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5306 net_5300 net_5273 net_5266 pch_25od w=26u l=0.415u
M_172 net_5252 net_5306 net_5293 net_5266 pch_25od w=26u l=0.415u
M_173 VDD net_5271 net_5303 VDD pch_25od w=5u l=0.415u
M_174 net_5266 net_5306 VDDPST net_5266 pch_25od w=24u l=0.415u
M_175 net_5266 net_5300 net_5273 net_5266 pch_25od w=24u l=0.415u
M_176 net_5252 net_5300 net_5273 net_5266 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD24DGZ
.SUBCKT PRD24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5308 net_5309 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5310 net_5311 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5312 net_5313 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5309 net_5309 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5314 net_5314 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5310 net_5310 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5314 net_5310 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5311 net_5311 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5311 net_5311 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5311 net_5311 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5309 net_5314 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5313 net_5308 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_14 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_15 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_16 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_17 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_18 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_19 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_20 net_5315 net_5315 rppolywo w=0.4u l=1.3u m=1
X_21 net_5316 net_5316 rppolywo w=0.4u l=1.3u m=1
X_22 net_5316 net_5316 rppolywo w=0.4u l=1.3u m=1
X_23 net_5317 net_5317 rppolywo w=0.4u l=1.3u m=1
X_24 net_5317 net_5317 rppolywo w=0.4u l=1.3u m=1
X_25 net_5317 net_5317 rppolywo w=0.4u l=1.3u m=1
X_26 net_5318 net_5315 rppolywo w=0.4u l=1.3u m=1
X_27 net_5315 net_5316 rppolywo w=0.4u l=1.3u m=1
X_28 net_5316 net_5317 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5319 net_5320 VSS nch_25od w=33u l=0.5u
M_30 net_5321 net_5314 VSS VSS nch_25od w=33u l=0.5u
M_31 net_5322 net_5314 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_5319 net_5321 VSS nch_25od w=33u l=0.5u
M_33 PAD net_5319 net_5322 VSS nch_25od w=33u l=0.5u
M_34 net_5323 net_5311 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5324 net_5311 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5325 net_5311 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5320 net_5313 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_5319 net_5323 VSS nch_25od w=33u l=0.5u
M_39 PAD net_5319 net_5324 VSS nch_25od w=33u l=0.5u
M_40 PAD net_5319 net_5325 VSS nch_25od w=33u l=0.5u
M_41 PAD net_5319 net_5326 VSS nch_25od w=33u l=0.5u
M_42 PAD net_5319 net_5327 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5319 net_5328 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5319 net_5329 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5319 net_5330 VSS nch_25od w=33u l=0.5u
M_46 net_5329 net_5309 VSS VSS nch_25od w=33u l=0.5u
M_47 net_5330 net_5309 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_5319 net_5331 VSS nch_25od w=33u l=0.5u
M_49 net_5326 net_5310 VSS VSS nch_25od w=33u l=0.5u
M_50 net_5327 net_5310 VSS VSS nch_25od w=33u l=0.5u
M_51 net_5328 net_5310 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5331 net_5308 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_54 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_55 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_56 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_57 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_58 PAD net_5316 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_59 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_60 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_61 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_62 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_63 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_64 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_65 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_66 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_67 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_68 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_69 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_70 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_71 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_72 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_73 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_74 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_75 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_76 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_77 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_78 PAD net_5315 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_79 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_80 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_81 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_82 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_83 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_84 PAD net_5317 VDDPST net_5332 pch_25od w=16.5u l=0.415u
M_85 net_5333 net_5334 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5332 net_5332 net_5332 net_5332 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5335 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_5336 net_5337 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_5336 net_5333 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5337 net_5333 net_5336 VSS nch_25od w=5u l=0.5u
M_91 net_5338 net_5337 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5337 net_5333 net_5338 VDDPST pch_25od w=5u l=0.415u
M_93 net_5338 net_5339 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5340 net_5341 net_5312 VDDPST pch_25od w=20u l=0.415u
M_95 net_5340 net_5342 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5312 net_5342 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5341 net_5312 VSS nch_25od w=15u l=0.5u
M_98 net_5343 net_5344 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5345 net_5346 net_5347 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5348 VSS nch_25od w=10u l=0.5u
M_101 net_5349 net_5346 net_5350 VSS nch_25od w=10u l=0.5u
M_102 net_5348 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5348 net_5343 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5348 net_5343 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5350 VSS nch w=10u l=0.09u
M_106 net_5345 net_5344 VSS VSS nch w=10u l=0.09u
M_107 net_5349 I net_5348 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5343 net_5344 net_5347 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5351 net_5352 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5353 net_5346 net_5354 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5355 VSS nch_25od w=10u l=0.5u
M_112 net_5356 net_5346 net_5357 VSS nch_25od w=10u l=0.5u
M_113 net_5355 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5355 net_5351 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5355 net_5351 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5357 VSS nch w=10u l=0.09u
M_117 net_5353 net_5352 VSS VSS nch w=10u l=0.09u
M_118 net_5356 OEN net_5355 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5351 net_5352 net_5354 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5358 net_5359 VDDPST pch_25od w=40u l=0.415u
M_121 net_5359 net_5360 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5361 net_5358 net_5359 VSS nch_25od w=20u l=0.5u
M_123 net_5361 net_5360 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5362 net_5363 VSS nch w=3u l=0.1u
M_125 net_5362 net_5363 VDD VDD pch w=4u l=0.1u
M_126 net_5363 net_5362 net_5362 VDD pch w=4u l=0.1u
M_127 net_5334 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5335 net_5364 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5334 net_5363 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5334 net_5335 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5335 net_5334 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5346 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5346 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5339 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5365 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5366 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5319 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5363 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5367 net_5343 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5367 net_5343 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5360 net_5351 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5360 net_5351 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5341 net_5348 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5341 net_5348 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5358 net_5367 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5358 net_5367 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5342 net_5355 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5342 net_5355 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5344 I VSS VSS nch w=3u l=0.09u
M_152 net_5344 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5352 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5352 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5364 net_5363 VSS VSS nch w=3u l=0.09u
M_156 net_5364 net_5363 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5368 C VSS nch w=20u l=0.09u
M_158 VSS net_5369 net_5368 VSS nch w=10u l=0.09u
M_159 VDD net_5368 C VDD pch w=30u l=0.09u
M_160 VDD net_5369 net_5368 VDD pch w=10u l=0.09u
M_161 VSS net_5337 net_5370 VSS nch_25od w=0.6u l=0.5u
M_162 net_5369 net_5370 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5371 net_5360 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5372 net_5366 net_5371 VSS nch_25od w=10u l=0.5u
M_165 net_5318 net_5366 net_5359 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5337 net_5369 VSS nch_25od w=5u l=0.5u
M_167 net_5339 net_5366 net_5333 VSS nch_25od w=30u l=0.5u
M_168 net_5373 net_5366 net_5372 VSS nch_25od w=10u l=0.5u
M_169 net_5333 net_5342 net_5373 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5337 net_5370 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5372 net_5366 net_5339 net_5332 pch_25od w=26u l=0.415u
M_172 net_5318 net_5372 net_5359 net_5332 pch_25od w=26u l=0.415u
M_173 VDD net_5337 net_5369 VDD pch_25od w=5u l=0.415u
M_174 net_5332 net_5372 VDDPST net_5332 pch_25od w=24u l=0.415u
M_175 net_5332 net_5366 net_5339 net_5332 pch_25od w=24u l=0.415u
M_176 net_5318 net_5366 net_5339 net_5332 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRD24SDGZ
.SUBCKT PRDW08DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5374 net_5375 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5376 net_5376 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5375 net_5377 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5378 net_5374 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5379 net_5378 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5380 net_5380 rppolywo w=0.4u l=1.3u m=1
X_14 net_5381 net_5381 rppolywo w=0.4u l=1.3u m=1
X_15 net_5382 net_5382 rppolywo w=0.4u l=1.3u m=1
X_16 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_17 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_18 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_19 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_20 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_21 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_22 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_23 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_24 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_25 net_5383 net_5383 rppolywo w=0.4u l=1.3u m=1
X_26 net_5384 net_5380 rppolywo w=0.4u l=1.3u m=1
X_27 net_5380 net_5381 rppolywo w=0.4u l=1.3u m=1
X_28 net_5381 net_5382 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5385 net_5386 VSS nch_25od w=33u l=0.5u
M_30 PAD net_5385 net_5387 VSS nch_25od w=33u l=0.5u
M_31 net_5387 net_5378 VSS VSS nch_25od w=33u l=0.5u
M_32 net_5386 net_5375 VSS VSS nch_25od w=33u l=0.5u
M_33 net_5388 net_5374 VSS VSS nch_25od w=33u l=0.5u
M_34 net_5389 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5390 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5391 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5392 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5393 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5394 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5395 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5396 net_5376 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_5385 net_5389 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5385 net_5390 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5385 net_5391 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5385 net_5392 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5385 net_5393 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5385 net_5394 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5385 net_5395 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5385 net_5396 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5385 net_5388 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5385 net_5397 VSS nch_25od w=33u l=0.5u
M_52 net_5397 net_5377 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5380 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_54 PAD net_5380 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_55 PAD net_5380 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_56 PAD net_5380 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_57 PAD net_5381 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_58 PAD net_5381 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_59 PAD net_5381 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_60 PAD net_5381 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_61 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_62 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_63 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_64 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_65 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_66 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_67 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_68 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_69 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_70 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_71 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_72 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_73 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_74 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_75 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_76 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_77 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_78 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_79 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_80 PAD net_5383 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_81 PAD net_5382 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_82 PAD net_5382 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_83 PAD net_5382 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_84 PAD net_5382 VDDPST net_5383 pch_25od w=16.5u l=0.415u
M_85 net_5398 net_5399 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5383 net_5383 net_5383 net_5383 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5400 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5401 net_5398 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5402 net_5398 net_5401 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5402 net_5398 net_5403 VDDPST pch_25od w=5u l=0.415u
M_93 net_5403 net_5404 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5405 net_5406 net_5379 VDDPST pch_25od w=20u l=0.415u
M_95 net_5405 net_5407 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5379 net_5407 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5406 net_5379 VSS nch_25od w=15u l=0.5u
M_98 net_5408 net_5409 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5410 net_5411 net_5412 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5413 VSS nch_25od w=10u l=0.5u
M_101 net_5414 net_5411 net_5415 VSS nch_25od w=10u l=0.5u
M_102 net_5413 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5413 net_5408 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5413 net_5408 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5415 VSS nch w=10u l=0.09u
M_106 net_5410 net_5409 VSS VSS nch w=10u l=0.09u
M_107 net_5414 I net_5413 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5408 net_5409 net_5412 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5416 net_5417 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5418 net_5411 net_5419 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5420 VSS nch_25od w=10u l=0.5u
M_112 net_5421 net_5411 net_5422 VSS nch_25od w=10u l=0.5u
M_113 net_5420 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5420 net_5416 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5420 net_5416 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5422 VSS nch w=10u l=0.09u
M_117 net_5418 net_5417 VSS VSS nch w=10u l=0.09u
M_118 net_5421 OEN net_5420 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5416 net_5417 net_5419 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5423 net_5424 VDDPST pch_25od w=40u l=0.415u
M_121 net_5424 net_5425 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5426 net_5423 net_5424 VSS nch_25od w=20u l=0.5u
M_123 net_5426 net_5425 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5427 net_5428 VSS nch w=3u l=0.1u
M_125 net_5427 net_5428 VDD VDD pch w=4u l=0.1u
M_126 net_5428 net_5427 net_5427 VDD pch w=4u l=0.1u
M_127 net_5399 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5400 net_5429 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5399 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_5399 net_5400 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5400 net_5399 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5411 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5411 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5404 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5376 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5430 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5385 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5431 net_5408 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5431 net_5408 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5425 net_5416 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5425 net_5416 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5406 net_5413 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5406 net_5413 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5423 net_5431 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5423 net_5431 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5407 net_5420 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5407 net_5420 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5409 I VSS VSS nch w=3u l=0.09u
M_152 net_5409 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5417 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5417 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5429 REN VSS VSS nch w=3u l=0.09u
M_156 net_5429 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5432 C VSS nch w=20u l=0.09u
M_158 VSS net_5433 net_5432 VSS nch w=10u l=0.09u
M_159 VDD net_5432 C VDD pch w=30u l=0.09u
M_160 VDD net_5433 net_5432 VDD pch w=10u l=0.09u
M_161 VSS net_5402 net_5434 VSS nch_25od w=0.6u l=0.5u
M_162 net_5433 net_5434 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5435 net_5425 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5436 net_5430 net_5435 VSS nch_25od w=10u l=0.5u
M_165 net_5384 net_5430 net_5424 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5402 net_5433 VSS nch_25od w=5u l=0.5u
M_167 net_5404 net_5430 net_5398 VSS nch_25od w=30u l=0.5u
M_168 net_5437 net_5430 net_5436 VSS nch_25od w=10u l=0.5u
M_169 net_5398 net_5407 net_5437 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5402 net_5434 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5436 net_5430 net_5404 net_5383 pch_25od w=26u l=0.415u
M_172 net_5384 net_5436 net_5424 net_5383 pch_25od w=26u l=0.415u
M_173 VDD net_5402 net_5433 VDD pch_25od w=5u l=0.415u
M_174 net_5383 net_5436 VDDPST net_5383 pch_25od w=24u l=0.415u
M_175 net_5383 net_5430 net_5404 net_5383 pch_25od w=24u l=0.415u
M_176 net_5384 net_5430 net_5404 net_5383 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRDW08DGZ
.SUBCKT PRDW12DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5438 net_5439 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5440 net_5441 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5442 net_5443 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5443 net_5444 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5445 net_5445 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5439 net_5442 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5441 net_5438 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5446 net_5446 rppolywo w=0.4u l=1.3u m=1
X_14 net_5446 net_5446 rppolywo w=0.4u l=1.3u m=1
X_15 net_5447 net_5447 rppolywo w=0.4u l=1.3u m=1
X_16 net_5447 net_5447 rppolywo w=0.4u l=1.3u m=1
X_17 net_5448 net_5448 rppolywo w=0.4u l=1.3u m=1
X_18 net_5448 net_5448 rppolywo w=0.4u l=1.3u m=1
X_19 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_20 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_21 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_22 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_23 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_24 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_25 net_5449 net_5449 rppolywo w=0.4u l=1.3u m=1
X_26 net_5450 net_5446 rppolywo w=0.4u l=1.3u m=1
X_27 net_5446 net_5447 rppolywo w=0.4u l=1.3u m=1
X_28 net_5447 net_5448 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5451 net_5452 VSS nch_25od w=33u l=0.5u
M_30 net_5453 net_5442 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5451 net_5453 VSS nch_25od w=33u l=0.5u
M_32 net_5452 net_5441 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5451 net_5454 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5451 net_5455 VSS nch_25od w=33u l=0.5u
M_35 net_5455 net_5439 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_5451 net_5456 VSS nch_25od w=33u l=0.5u
M_37 net_5454 net_5443 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5456 net_5438 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5457 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5458 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5459 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5460 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5461 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5462 net_5445 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5451 net_5457 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5451 net_5458 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5451 net_5459 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5451 net_5460 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5451 net_5461 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5451 net_5462 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5451 net_5463 VSS nch_25od w=33u l=0.5u
M_52 net_5463 net_5444 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_54 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_55 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_56 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_57 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_58 PAD net_5446 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_59 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_60 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_61 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_62 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_63 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_64 PAD net_5447 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_65 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_66 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_67 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_68 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_69 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_70 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_71 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_72 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_73 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_74 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_75 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_76 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_77 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_78 PAD net_5449 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_79 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_80 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_81 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_82 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_83 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_84 PAD net_5448 VDDPST net_5449 pch_25od w=16.5u l=0.415u
M_85 net_5464 net_5465 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5449 net_5449 net_5449 net_5449 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5466 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5467 net_5464 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5468 net_5464 net_5467 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5468 net_5464 net_5469 VDDPST pch_25od w=5u l=0.415u
M_93 net_5469 net_5470 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5471 net_5472 net_5440 VDDPST pch_25od w=20u l=0.415u
M_95 net_5471 net_5473 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5440 net_5473 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5472 net_5440 VSS nch_25od w=15u l=0.5u
M_98 net_5474 net_5475 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5476 net_5477 net_5478 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5479 VSS nch_25od w=10u l=0.5u
M_101 net_5480 net_5477 net_5481 VSS nch_25od w=10u l=0.5u
M_102 net_5479 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5479 net_5474 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5479 net_5474 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5481 VSS nch w=10u l=0.09u
M_106 net_5476 net_5475 VSS VSS nch w=10u l=0.09u
M_107 net_5480 I net_5479 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5474 net_5475 net_5478 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5482 net_5483 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5484 net_5477 net_5485 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5486 VSS nch_25od w=10u l=0.5u
M_112 net_5487 net_5477 net_5488 VSS nch_25od w=10u l=0.5u
M_113 net_5486 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5486 net_5482 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5486 net_5482 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5488 VSS nch w=10u l=0.09u
M_117 net_5484 net_5483 VSS VSS nch w=10u l=0.09u
M_118 net_5487 OEN net_5486 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5482 net_5483 net_5485 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5489 net_5490 VDDPST pch_25od w=40u l=0.415u
M_121 net_5490 net_5491 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5492 net_5489 net_5490 VSS nch_25od w=20u l=0.5u
M_123 net_5492 net_5491 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5493 net_5494 VSS nch w=3u l=0.1u
M_125 net_5493 net_5494 VDD VDD pch w=4u l=0.1u
M_126 net_5494 net_5493 net_5493 VDD pch w=4u l=0.1u
M_127 net_5465 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5466 net_5495 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5465 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_5465 net_5466 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5466 net_5465 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5477 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5477 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5470 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5445 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5496 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5451 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5497 net_5474 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5497 net_5474 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5491 net_5482 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5491 net_5482 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5472 net_5479 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5472 net_5479 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5489 net_5497 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5489 net_5497 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5473 net_5486 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5473 net_5486 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5475 I VSS VSS nch w=3u l=0.09u
M_152 net_5475 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5483 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5483 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5495 REN VSS VSS nch w=3u l=0.09u
M_156 net_5495 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5498 C VSS nch w=20u l=0.09u
M_158 VSS net_5499 net_5498 VSS nch w=10u l=0.09u
M_159 VDD net_5498 C VDD pch w=30u l=0.09u
M_160 VDD net_5499 net_5498 VDD pch w=10u l=0.09u
M_161 VSS net_5468 net_5500 VSS nch_25od w=0.6u l=0.5u
M_162 net_5499 net_5500 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5501 net_5491 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5502 net_5496 net_5501 VSS nch_25od w=10u l=0.5u
M_165 net_5450 net_5496 net_5490 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5468 net_5499 VSS nch_25od w=5u l=0.5u
M_167 net_5470 net_5496 net_5464 VSS nch_25od w=30u l=0.5u
M_168 net_5503 net_5496 net_5502 VSS nch_25od w=10u l=0.5u
M_169 net_5464 net_5473 net_5503 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5468 net_5500 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5502 net_5496 net_5470 net_5449 pch_25od w=26u l=0.415u
M_172 net_5450 net_5502 net_5490 net_5449 pch_25od w=26u l=0.415u
M_173 VDD net_5468 net_5499 VDD pch_25od w=5u l=0.415u
M_174 net_5449 net_5502 VDDPST net_5449 pch_25od w=24u l=0.415u
M_175 net_5449 net_5496 net_5470 net_5449 pch_25od w=24u l=0.415u
M_176 net_5450 net_5496 net_5470 net_5449 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRDW12DGZ
.SUBCKT PRDW16DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5504 net_5505 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5506 net_5507 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5508 net_5508 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5508 net_5508 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5508 net_5508 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5508 net_5508 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5509 net_5510 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5510 net_5511 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5511 net_5511 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5510 net_5510 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5505 net_5509 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5507 net_5504 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5512 net_5512 rppolywo w=0.4u l=1.3u m=1
X_14 net_5512 net_5512 rppolywo w=0.4u l=1.3u m=1
X_15 net_5512 net_5512 rppolywo w=0.4u l=1.3u m=1
X_16 net_5513 net_5513 rppolywo w=0.4u l=1.3u m=1
X_17 net_5513 net_5513 rppolywo w=0.4u l=1.3u m=1
X_18 net_5513 net_5513 rppolywo w=0.4u l=1.3u m=1
X_19 net_5514 net_5514 rppolywo w=0.4u l=1.3u m=1
X_20 net_5514 net_5514 rppolywo w=0.4u l=1.3u m=1
X_21 net_5514 net_5514 rppolywo w=0.4u l=1.3u m=1
X_22 net_5515 net_5515 rppolywo w=0.4u l=1.3u m=1
X_23 net_5515 net_5515 rppolywo w=0.4u l=1.3u m=1
X_24 net_5515 net_5515 rppolywo w=0.4u l=1.3u m=1
X_25 net_5515 net_5515 rppolywo w=0.4u l=1.3u m=1
X_26 net_5516 net_5513 rppolywo w=0.4u l=1.3u m=1
X_27 net_5513 net_5512 rppolywo w=0.4u l=1.3u m=1
X_28 net_5512 net_5514 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5517 net_5518 VSS nch_25od w=33u l=0.5u
M_30 net_5519 net_5509 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5517 net_5519 VSS nch_25od w=33u l=0.5u
M_32 net_5518 net_5507 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5517 net_5520 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5517 net_5521 VSS nch_25od w=33u l=0.5u
M_35 PAD net_5517 net_5522 VSS nch_25od w=33u l=0.5u
M_36 net_5522 net_5505 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_5517 net_5523 VSS nch_25od w=33u l=0.5u
M_38 net_5520 net_5510 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5521 net_5510 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5523 net_5504 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5524 net_5508 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5525 net_5508 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5526 net_5508 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5527 net_5508 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5517 net_5524 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5517 net_5525 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5517 net_5526 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5517 net_5527 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5517 net_5528 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5517 net_5529 VSS nch_25od w=33u l=0.5u
M_51 net_5528 net_5511 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5529 net_5511 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_54 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_55 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_56 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_57 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_58 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_59 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_60 PAD net_5512 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_61 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_62 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_63 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_64 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_65 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_66 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_67 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_68 PAD net_5513 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_69 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_70 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_71 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_72 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_73 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_74 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_75 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_76 PAD net_5515 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_77 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_78 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_79 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_80 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_81 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_82 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_83 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_84 PAD net_5514 VDDPST net_5515 pch_25od w=16.5u l=0.415u
M_85 net_5530 net_5531 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5515 net_5515 net_5515 net_5515 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5532 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5533 net_5530 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5534 net_5530 net_5533 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5534 net_5530 net_5535 VDDPST pch_25od w=5u l=0.415u
M_93 net_5535 net_5536 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5537 net_5538 net_5506 VDDPST pch_25od w=20u l=0.415u
M_95 net_5537 net_5539 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5506 net_5539 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5538 net_5506 VSS nch_25od w=15u l=0.5u
M_98 net_5540 net_5541 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5542 net_5543 net_5544 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5545 VSS nch_25od w=10u l=0.5u
M_101 net_5546 net_5543 net_5547 VSS nch_25od w=10u l=0.5u
M_102 net_5545 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5545 net_5540 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5545 net_5540 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5547 VSS nch w=10u l=0.09u
M_106 net_5542 net_5541 VSS VSS nch w=10u l=0.09u
M_107 net_5546 I net_5545 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5540 net_5541 net_5544 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5548 net_5549 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5550 net_5543 net_5551 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5552 VSS nch_25od w=10u l=0.5u
M_112 net_5553 net_5543 net_5554 VSS nch_25od w=10u l=0.5u
M_113 net_5552 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5552 net_5548 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5552 net_5548 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5554 VSS nch w=10u l=0.09u
M_117 net_5550 net_5549 VSS VSS nch w=10u l=0.09u
M_118 net_5553 OEN net_5552 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5548 net_5549 net_5551 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5555 net_5556 VDDPST pch_25od w=40u l=0.415u
M_121 net_5556 net_5557 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5558 net_5555 net_5556 VSS nch_25od w=20u l=0.5u
M_123 net_5558 net_5557 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5559 net_5560 VSS nch w=3u l=0.1u
M_125 net_5559 net_5560 VDD VDD pch w=4u l=0.1u
M_126 net_5560 net_5559 net_5559 VDD pch w=4u l=0.1u
M_127 net_5531 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5532 net_5561 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5531 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_5531 net_5532 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5532 net_5531 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5543 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5543 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5536 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5508 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5562 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5517 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5563 net_5540 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5563 net_5540 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5557 net_5548 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5557 net_5548 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5538 net_5545 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5538 net_5545 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5555 net_5563 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5555 net_5563 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5539 net_5552 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5539 net_5552 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5541 I VSS VSS nch w=3u l=0.09u
M_152 net_5541 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5549 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5549 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5561 REN VSS VSS nch w=3u l=0.09u
M_156 net_5561 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5564 C VSS nch w=20u l=0.09u
M_158 VSS net_5565 net_5564 VSS nch w=10u l=0.09u
M_159 VDD net_5564 C VDD pch w=30u l=0.09u
M_160 VDD net_5565 net_5564 VDD pch w=10u l=0.09u
M_161 VSS net_5534 net_5566 VSS nch_25od w=0.6u l=0.5u
M_162 net_5565 net_5566 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5567 net_5557 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5568 net_5562 net_5567 VSS nch_25od w=10u l=0.5u
M_165 net_5516 net_5562 net_5556 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5534 net_5565 VSS nch_25od w=5u l=0.5u
M_167 net_5536 net_5562 net_5530 VSS nch_25od w=30u l=0.5u
M_168 net_5569 net_5562 net_5568 VSS nch_25od w=10u l=0.5u
M_169 net_5530 net_5539 net_5569 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5534 net_5566 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5568 net_5562 net_5536 net_5515 pch_25od w=26u l=0.415u
M_172 net_5516 net_5568 net_5556 net_5515 pch_25od w=26u l=0.415u
M_173 VDD net_5534 net_5565 VDD pch_25od w=5u l=0.415u
M_174 net_5515 net_5568 VDDPST net_5515 pch_25od w=24u l=0.415u
M_175 net_5515 net_5562 net_5536 net_5515 pch_25od w=24u l=0.415u
M_176 net_5516 net_5562 net_5536 net_5515 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRDW16DGZ
.SUBCKT PRDW24DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5570 net_5571 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5572 net_5573 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5574 net_5575 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5571 net_5571 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5576 net_5576 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5572 net_5572 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5576 net_5572 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5573 net_5573 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5573 net_5573 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5573 net_5573 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5571 net_5576 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5575 net_5570 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_14 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_15 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_16 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_17 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_18 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_19 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_20 net_5577 net_5577 rppolywo w=0.4u l=1.3u m=1
X_21 net_5578 net_5578 rppolywo w=0.4u l=1.3u m=1
X_22 net_5578 net_5578 rppolywo w=0.4u l=1.3u m=1
X_23 net_5579 net_5579 rppolywo w=0.4u l=1.3u m=1
X_24 net_5579 net_5579 rppolywo w=0.4u l=1.3u m=1
X_25 net_5579 net_5579 rppolywo w=0.4u l=1.3u m=1
X_26 net_5580 net_5577 rppolywo w=0.4u l=1.3u m=1
X_27 net_5577 net_5578 rppolywo w=0.4u l=1.3u m=1
X_28 net_5578 net_5579 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5581 net_5582 VSS nch_25od w=33u l=0.5u
M_30 net_5583 net_5576 VSS VSS nch_25od w=33u l=0.5u
M_31 net_5584 net_5576 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_5581 net_5583 VSS nch_25od w=33u l=0.5u
M_33 PAD net_5581 net_5584 VSS nch_25od w=33u l=0.5u
M_34 net_5585 net_5573 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5586 net_5573 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5587 net_5573 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5582 net_5575 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_5581 net_5585 VSS nch_25od w=33u l=0.5u
M_39 PAD net_5581 net_5586 VSS nch_25od w=33u l=0.5u
M_40 PAD net_5581 net_5587 VSS nch_25od w=33u l=0.5u
M_41 PAD net_5581 net_5588 VSS nch_25od w=33u l=0.5u
M_42 PAD net_5581 net_5589 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5581 net_5590 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5581 net_5591 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5581 net_5592 VSS nch_25od w=33u l=0.5u
M_46 net_5591 net_5571 VSS VSS nch_25od w=33u l=0.5u
M_47 net_5592 net_5571 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_5581 net_5593 VSS nch_25od w=33u l=0.5u
M_49 net_5588 net_5572 VSS VSS nch_25od w=33u l=0.5u
M_50 net_5589 net_5572 VSS VSS nch_25od w=33u l=0.5u
M_51 net_5590 net_5572 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5593 net_5570 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_54 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_55 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_56 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_57 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_58 PAD net_5578 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_59 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_60 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_61 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_62 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_63 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_64 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_65 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_66 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_67 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_68 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_69 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_70 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_71 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_72 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_73 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_74 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_75 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_76 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_77 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_78 PAD net_5577 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_79 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_80 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_81 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_82 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_83 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_84 PAD net_5579 VDDPST net_5594 pch_25od w=16.5u l=0.415u
M_85 net_5595 net_5596 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5594 net_5594 net_5594 net_5594 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5597 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_5598 net_5595 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5599 net_5595 net_5598 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5599 net_5595 net_5600 VDDPST pch_25od w=5u l=0.415u
M_93 net_5600 net_5601 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5602 net_5603 net_5574 VDDPST pch_25od w=20u l=0.415u
M_95 net_5602 net_5604 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5574 net_5604 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5603 net_5574 VSS nch_25od w=15u l=0.5u
M_98 net_5605 net_5606 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5607 net_5608 net_5609 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5610 VSS nch_25od w=10u l=0.5u
M_101 net_5611 net_5608 net_5612 VSS nch_25od w=10u l=0.5u
M_102 net_5610 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5610 net_5605 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5610 net_5605 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5612 VSS nch w=10u l=0.09u
M_106 net_5607 net_5606 VSS VSS nch w=10u l=0.09u
M_107 net_5611 I net_5610 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5605 net_5606 net_5609 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5613 net_5614 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5615 net_5608 net_5616 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5617 VSS nch_25od w=10u l=0.5u
M_112 net_5618 net_5608 net_5619 VSS nch_25od w=10u l=0.5u
M_113 net_5617 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5617 net_5613 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5617 net_5613 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5619 VSS nch w=10u l=0.09u
M_117 net_5615 net_5614 VSS VSS nch w=10u l=0.09u
M_118 net_5618 OEN net_5617 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5613 net_5614 net_5616 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5620 net_5621 VDDPST pch_25od w=40u l=0.415u
M_121 net_5621 net_5622 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5623 net_5620 net_5621 VSS nch_25od w=20u l=0.5u
M_123 net_5623 net_5622 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5624 net_5625 VSS nch w=3u l=0.1u
M_125 net_5624 net_5625 VDD VDD pch w=4u l=0.1u
M_126 net_5625 net_5624 net_5624 VDD pch w=4u l=0.1u
M_127 net_5596 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5597 net_5626 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5596 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_5596 net_5597 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5597 net_5596 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5608 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5608 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5601 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5627 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5628 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5581 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5629 net_5605 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5629 net_5605 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5622 net_5613 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5622 net_5613 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5603 net_5610 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5603 net_5610 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5620 net_5629 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5620 net_5629 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5604 net_5617 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5604 net_5617 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5606 I VSS VSS nch w=3u l=0.09u
M_152 net_5606 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5614 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5614 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5626 REN VSS VSS nch w=3u l=0.09u
M_156 net_5626 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5630 C VSS nch w=20u l=0.09u
M_158 VSS net_5631 net_5630 VSS nch w=10u l=0.09u
M_159 VDD net_5630 C VDD pch w=30u l=0.09u
M_160 VDD net_5631 net_5630 VDD pch w=10u l=0.09u
M_161 VSS net_5599 net_5632 VSS nch_25od w=0.6u l=0.5u
M_162 net_5631 net_5632 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5633 net_5622 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5634 net_5628 net_5633 VSS nch_25od w=10u l=0.5u
M_165 net_5580 net_5628 net_5621 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5599 net_5631 VSS nch_25od w=5u l=0.5u
M_167 net_5601 net_5628 net_5595 VSS nch_25od w=30u l=0.5u
M_168 net_5635 net_5628 net_5634 VSS nch_25od w=10u l=0.5u
M_169 net_5595 net_5604 net_5635 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5599 net_5632 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5634 net_5628 net_5601 net_5594 pch_25od w=26u l=0.415u
M_172 net_5580 net_5634 net_5621 net_5594 pch_25od w=26u l=0.415u
M_173 VDD net_5599 net_5631 VDD pch_25od w=5u l=0.415u
M_174 net_5594 net_5634 VDDPST net_5594 pch_25od w=24u l=0.415u
M_175 net_5594 net_5628 net_5601 net_5594 pch_25od w=24u l=0.415u
M_176 net_5580 net_5628 net_5601 net_5594 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRDW24DGZ
.SUBCKT PRO08CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5636 net_5637 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5638 net_5638 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5637 net_5639 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5640 net_5636 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5641 net_5640 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5642 net_5642 rppolywo w=0.4u l=1.3u m=1
X_14 net_5643 net_5643 rppolywo w=0.4u l=1.3u m=1
X_15 net_5644 net_5644 rppolywo w=0.4u l=1.3u m=1
X_16 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_17 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_18 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_19 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_20 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_21 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_22 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_23 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_24 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_25 net_5645 net_5645 rppolywo w=0.4u l=1.3u m=1
X_26 net_5646 net_5642 rppolywo w=0.4u l=1.3u m=1
X_27 net_5642 net_5643 rppolywo w=0.4u l=1.3u m=1
X_28 net_5643 net_5644 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5647 net_5648 VSS nch_25od w=33u l=0.5u
M_30 PAD net_5647 net_5649 VSS nch_25od w=33u l=0.5u
M_31 net_5649 net_5640 VSS VSS nch_25od w=33u l=0.5u
M_32 net_5648 net_5637 VSS VSS nch_25od w=33u l=0.5u
M_33 net_5650 net_5636 VSS VSS nch_25od w=33u l=0.5u
M_34 net_5651 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5652 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5653 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5654 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5655 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5656 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5657 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5658 net_5638 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_5647 net_5651 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5647 net_5652 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5647 net_5653 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5647 net_5654 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5647 net_5655 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5647 net_5656 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5647 net_5657 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5647 net_5658 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5647 net_5650 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5647 net_5659 VSS nch_25od w=33u l=0.5u
M_52 net_5659 net_5639 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5642 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_54 PAD net_5642 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_55 PAD net_5642 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_56 PAD net_5642 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_57 PAD net_5643 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_58 PAD net_5643 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_59 PAD net_5643 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_60 PAD net_5643 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_61 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_62 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_63 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_64 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_65 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_66 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_67 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_68 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_69 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_70 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_71 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_72 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_73 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_74 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_75 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_76 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_77 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_78 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_79 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_80 PAD net_5645 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_81 PAD net_5644 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_82 PAD net_5644 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_83 PAD net_5644 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_84 PAD net_5644 VDDPST net_5645 pch_25od w=16.5u l=0.415u
M_85 VSS net_5660 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5645 net_5645 net_5645 net_5645 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5661 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_5662 net_5662 VSS nch_25od w=2.1u l=0.5u
M_89 net_5663 net_5664 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5665 net_5664 net_5663 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_5662 net_5664 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5665 net_5664 net_5666 VDDPST pch_25od w=5u l=0.415u
M_93 net_5666 net_5667 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5668 net_5669 net_5641 VDDPST pch_25od w=20u l=0.415u
M_95 net_5668 net_5670 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5641 net_5670 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5669 net_5641 VSS nch_25od w=15u l=0.5u
M_98 net_5671 net_5672 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5673 net_5674 net_5675 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5676 VSS nch_25od w=10u l=0.5u
M_101 net_5677 net_5674 net_5678 VSS nch_25od w=10u l=0.5u
M_102 net_5676 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5676 net_5671 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5676 net_5671 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5678 VSS nch w=10u l=0.09u
M_106 net_5673 net_5672 VSS VSS nch w=10u l=0.09u
M_107 net_5677 I net_5676 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5671 net_5672 net_5675 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5679 net_5680 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5681 net_5674 net_5682 VSS nch_25od w=10u l=0.5u
M_111 VSS net_5683 net_5684 VSS nch_25od w=10u l=0.5u
M_112 net_5685 net_5674 net_5686 VSS nch_25od w=10u l=0.5u
M_113 net_5684 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5684 net_5679 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5684 net_5679 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_5683 net_5686 VSS nch w=10u l=0.09u
M_117 net_5681 net_5680 VSS VSS nch w=10u l=0.09u
M_118 net_5685 net_5683 net_5684 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5679 net_5680 net_5682 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5687 net_5688 VDDPST pch_25od w=40u l=0.415u
M_121 net_5688 net_5689 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5690 net_5687 net_5688 VSS nch_25od w=20u l=0.5u
M_123 net_5690 net_5689 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5691 net_5683 VSS nch w=3u l=0.1u
M_125 net_5691 net_5683 VDD VDD pch w=4u l=0.1u
M_126 net_5683 net_5691 net_5691 VDD pch w=4u l=0.1u
M_127 net_5660 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5661 net_5692 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5660 net_5691 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5660 net_5661 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5661 net_5660 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5674 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5674 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5667 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5638 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5693 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5647 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5691 ndio area=4p
D_139 VSS net_5683 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5694 net_5671 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5694 net_5671 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5689 net_5679 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5689 net_5679 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5669 net_5676 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5669 net_5676 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5687 net_5694 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5687 net_5694 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5670 net_5684 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5670 net_5684 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5672 I VSS VSS nch w=3u l=0.09u
M_152 net_5672 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5680 net_5683 VSS VSS nch w=3u l=0.09u
M_154 net_5680 net_5683 VDD VDD pch w=7.5u l=0.09u
M_155 net_5692 net_5691 VSS VSS nch w=3u l=0.09u
M_156 net_5692 net_5691 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5695 net_5696 VSS nch w=20u l=0.09u
M_158 VSS net_5697 net_5695 VSS nch w=10u l=0.09u
M_159 VDD net_5695 net_5696 VDD pch w=30u l=0.09u
M_160 VDD net_5697 net_5695 VDD pch w=10u l=0.09u
M_161 VSS net_5665 net_5698 VSS nch_25od w=0.6u l=0.5u
M_162 net_5697 net_5698 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5699 net_5689 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5700 net_5693 net_5699 VSS nch_25od w=10u l=0.5u
M_165 net_5646 net_5693 net_5688 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5665 net_5697 VSS nch_25od w=5u l=0.5u
M_167 net_5667 net_5693 net_5701 VSS nch_25od w=30u l=0.5u
M_168 net_5702 net_5693 net_5700 VSS nch_25od w=10u l=0.5u
M_169 net_5701 net_5670 net_5702 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5665 net_5698 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5700 net_5693 net_5667 net_5645 pch_25od w=26u l=0.415u
M_172 net_5646 net_5700 net_5688 net_5645 pch_25od w=26u l=0.415u
M_173 VDD net_5665 net_5697 VDD pch_25od w=5u l=0.415u
M_174 net_5645 net_5700 VDDPST net_5645 pch_25od w=24u l=0.415u
M_175 net_5645 net_5693 net_5667 net_5645 pch_25od w=24u l=0.415u
M_176 net_5646 net_5693 net_5667 net_5645 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRO08CDG
.SUBCKT PRO12CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5703 net_5704 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5705 net_5706 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5707 net_5708 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5708 net_5709 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5710 net_5710 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5704 net_5707 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5706 net_5703 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5711 net_5711 rppolywo w=0.4u l=1.3u m=1
X_14 net_5711 net_5711 rppolywo w=0.4u l=1.3u m=1
X_15 net_5712 net_5712 rppolywo w=0.4u l=1.3u m=1
X_16 net_5712 net_5712 rppolywo w=0.4u l=1.3u m=1
X_17 net_5713 net_5713 rppolywo w=0.4u l=1.3u m=1
X_18 net_5713 net_5713 rppolywo w=0.4u l=1.3u m=1
X_19 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_20 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_21 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_22 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_23 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_24 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_25 net_5714 net_5714 rppolywo w=0.4u l=1.3u m=1
X_26 net_5715 net_5711 rppolywo w=0.4u l=1.3u m=1
X_27 net_5711 net_5712 rppolywo w=0.4u l=1.3u m=1
X_28 net_5712 net_5713 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5716 net_5717 VSS nch_25od w=33u l=0.5u
M_30 net_5718 net_5707 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5716 net_5718 VSS nch_25od w=33u l=0.5u
M_32 net_5717 net_5706 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5716 net_5719 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5716 net_5720 VSS nch_25od w=33u l=0.5u
M_35 net_5720 net_5704 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_5716 net_5721 VSS nch_25od w=33u l=0.5u
M_37 net_5719 net_5708 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5721 net_5703 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5722 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5723 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5724 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5725 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5726 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5727 net_5710 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5716 net_5722 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5716 net_5723 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5716 net_5724 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5716 net_5725 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5716 net_5726 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5716 net_5727 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5716 net_5728 VSS nch_25od w=33u l=0.5u
M_52 net_5728 net_5709 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_54 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_55 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_56 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_57 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_58 PAD net_5711 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_59 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_60 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_61 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_62 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_63 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_64 PAD net_5712 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_65 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_66 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_67 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_68 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_69 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_70 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_71 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_72 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_73 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_74 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_75 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_76 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_77 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_78 PAD net_5714 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_79 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_80 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_81 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_82 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_83 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_84 PAD net_5713 VDDPST net_5714 pch_25od w=16.5u l=0.415u
M_85 VSS net_5729 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5714 net_5714 net_5714 net_5714 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5730 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_5731 net_5731 VSS nch_25od w=2.1u l=0.5u
M_89 net_5732 net_5733 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5734 net_5733 net_5732 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_5731 net_5733 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5734 net_5733 net_5735 VDDPST pch_25od w=5u l=0.415u
M_93 net_5735 net_5736 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5737 net_5738 net_5705 VDDPST pch_25od w=20u l=0.415u
M_95 net_5737 net_5739 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5705 net_5739 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5738 net_5705 VSS nch_25od w=15u l=0.5u
M_98 net_5740 net_5741 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5742 net_5743 net_5744 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5745 VSS nch_25od w=10u l=0.5u
M_101 net_5746 net_5743 net_5747 VSS nch_25od w=10u l=0.5u
M_102 net_5745 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5745 net_5740 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5745 net_5740 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5747 VSS nch w=10u l=0.09u
M_106 net_5742 net_5741 VSS VSS nch w=10u l=0.09u
M_107 net_5746 I net_5745 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5740 net_5741 net_5744 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5748 net_5749 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5750 net_5743 net_5751 VSS nch_25od w=10u l=0.5u
M_111 VSS net_5752 net_5753 VSS nch_25od w=10u l=0.5u
M_112 net_5754 net_5743 net_5755 VSS nch_25od w=10u l=0.5u
M_113 net_5753 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5753 net_5748 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5753 net_5748 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_5752 net_5755 VSS nch w=10u l=0.09u
M_117 net_5750 net_5749 VSS VSS nch w=10u l=0.09u
M_118 net_5754 net_5752 net_5753 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5748 net_5749 net_5751 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5756 net_5757 VDDPST pch_25od w=40u l=0.415u
M_121 net_5757 net_5758 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5759 net_5756 net_5757 VSS nch_25od w=20u l=0.5u
M_123 net_5759 net_5758 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5760 net_5752 VSS nch w=3u l=0.1u
M_125 net_5760 net_5752 VDD VDD pch w=4u l=0.1u
M_126 net_5752 net_5760 net_5760 VDD pch w=4u l=0.1u
M_127 net_5729 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5730 net_5761 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5729 net_5760 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5729 net_5730 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5730 net_5729 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5743 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5743 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5736 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5710 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5762 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5716 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5760 ndio area=4p
D_139 VSS net_5752 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5763 net_5740 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5763 net_5740 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5758 net_5748 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5758 net_5748 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5738 net_5745 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5738 net_5745 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5756 net_5763 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5756 net_5763 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5739 net_5753 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5739 net_5753 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5741 I VSS VSS nch w=3u l=0.09u
M_152 net_5741 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5749 net_5752 VSS VSS nch w=3u l=0.09u
M_154 net_5749 net_5752 VDD VDD pch w=7.5u l=0.09u
M_155 net_5761 net_5760 VSS VSS nch w=3u l=0.09u
M_156 net_5761 net_5760 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5764 net_5765 VSS nch w=20u l=0.09u
M_158 VSS net_5766 net_5764 VSS nch w=10u l=0.09u
M_159 VDD net_5764 net_5765 VDD pch w=30u l=0.09u
M_160 VDD net_5766 net_5764 VDD pch w=10u l=0.09u
M_161 VSS net_5734 net_5767 VSS nch_25od w=0.6u l=0.5u
M_162 net_5766 net_5767 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5768 net_5758 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5769 net_5762 net_5768 VSS nch_25od w=10u l=0.5u
M_165 net_5715 net_5762 net_5757 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5734 net_5766 VSS nch_25od w=5u l=0.5u
M_167 net_5736 net_5762 net_5770 VSS nch_25od w=30u l=0.5u
M_168 net_5771 net_5762 net_5769 VSS nch_25od w=10u l=0.5u
M_169 net_5770 net_5739 net_5771 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5734 net_5767 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5769 net_5762 net_5736 net_5714 pch_25od w=26u l=0.415u
M_172 net_5715 net_5769 net_5757 net_5714 pch_25od w=26u l=0.415u
M_173 VDD net_5734 net_5766 VDD pch_25od w=5u l=0.415u
M_174 net_5714 net_5769 VDDPST net_5714 pch_25od w=24u l=0.415u
M_175 net_5714 net_5762 net_5736 net_5714 pch_25od w=24u l=0.415u
M_176 net_5715 net_5762 net_5736 net_5714 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRO12CDG
.SUBCKT PRO16CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5772 net_5773 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5774 net_5775 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5776 net_5776 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5776 net_5776 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5776 net_5776 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5776 net_5776 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5777 net_5778 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5778 net_5779 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5779 net_5779 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5778 net_5778 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5773 net_5777 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5775 net_5772 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5780 net_5780 rppolywo w=0.4u l=1.3u m=1
X_14 net_5780 net_5780 rppolywo w=0.4u l=1.3u m=1
X_15 net_5780 net_5780 rppolywo w=0.4u l=1.3u m=1
X_16 net_5781 net_5781 rppolywo w=0.4u l=1.3u m=1
X_17 net_5781 net_5781 rppolywo w=0.4u l=1.3u m=1
X_18 net_5781 net_5781 rppolywo w=0.4u l=1.3u m=1
X_19 net_5782 net_5782 rppolywo w=0.4u l=1.3u m=1
X_20 net_5782 net_5782 rppolywo w=0.4u l=1.3u m=1
X_21 net_5782 net_5782 rppolywo w=0.4u l=1.3u m=1
X_22 net_5783 net_5783 rppolywo w=0.4u l=1.3u m=1
X_23 net_5783 net_5783 rppolywo w=0.4u l=1.3u m=1
X_24 net_5783 net_5783 rppolywo w=0.4u l=1.3u m=1
X_25 net_5783 net_5783 rppolywo w=0.4u l=1.3u m=1
X_26 net_5784 net_5781 rppolywo w=0.4u l=1.3u m=1
X_27 net_5781 net_5780 rppolywo w=0.4u l=1.3u m=1
X_28 net_5780 net_5782 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5785 net_5786 VSS nch_25od w=33u l=0.5u
M_30 net_5787 net_5777 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5785 net_5787 VSS nch_25od w=33u l=0.5u
M_32 net_5786 net_5775 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5785 net_5788 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5785 net_5789 VSS nch_25od w=33u l=0.5u
M_35 PAD net_5785 net_5790 VSS nch_25od w=33u l=0.5u
M_36 net_5790 net_5773 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_5785 net_5791 VSS nch_25od w=33u l=0.5u
M_38 net_5788 net_5778 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5789 net_5778 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5791 net_5772 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5792 net_5776 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5793 net_5776 VSS VSS nch_25od w=33u l=0.5u
M_43 net_5794 net_5776 VSS VSS nch_25od w=33u l=0.5u
M_44 net_5795 net_5776 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5785 net_5792 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5785 net_5793 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5785 net_5794 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5785 net_5795 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5785 net_5796 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5785 net_5797 VSS nch_25od w=33u l=0.5u
M_51 net_5796 net_5779 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5797 net_5779 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_54 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_55 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_56 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_57 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_58 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_59 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_60 PAD net_5780 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_61 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_62 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_63 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_64 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_65 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_66 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_67 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_68 PAD net_5781 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_69 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_70 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_71 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_72 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_73 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_74 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_75 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_76 PAD net_5783 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_77 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_78 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_79 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_80 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_81 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_82 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_83 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_84 PAD net_5782 VDDPST net_5783 pch_25od w=16.5u l=0.415u
M_85 VSS net_5798 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5783 net_5783 net_5783 net_5783 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5799 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_5800 net_5800 VSS nch_25od w=2.1u l=0.5u
M_89 net_5801 net_5802 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5803 net_5802 net_5801 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_5800 net_5802 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5803 net_5802 net_5804 VDDPST pch_25od w=5u l=0.415u
M_93 net_5804 net_5805 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5806 net_5807 net_5774 VDDPST pch_25od w=20u l=0.415u
M_95 net_5806 net_5808 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5774 net_5808 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5807 net_5774 VSS nch_25od w=15u l=0.5u
M_98 net_5809 net_5810 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5811 net_5812 net_5813 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5814 VSS nch_25od w=10u l=0.5u
M_101 net_5815 net_5812 net_5816 VSS nch_25od w=10u l=0.5u
M_102 net_5814 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5814 net_5809 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5814 net_5809 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5816 VSS nch w=10u l=0.09u
M_106 net_5811 net_5810 VSS VSS nch w=10u l=0.09u
M_107 net_5815 I net_5814 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5809 net_5810 net_5813 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5817 net_5818 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5819 net_5812 net_5820 VSS nch_25od w=10u l=0.5u
M_111 VSS net_5821 net_5822 VSS nch_25od w=10u l=0.5u
M_112 net_5823 net_5812 net_5824 VSS nch_25od w=10u l=0.5u
M_113 net_5822 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5822 net_5817 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5822 net_5817 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_5821 net_5824 VSS nch w=10u l=0.09u
M_117 net_5819 net_5818 VSS VSS nch w=10u l=0.09u
M_118 net_5823 net_5821 net_5822 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5817 net_5818 net_5820 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5825 net_5826 VDDPST pch_25od w=40u l=0.415u
M_121 net_5826 net_5827 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5828 net_5825 net_5826 VSS nch_25od w=20u l=0.5u
M_123 net_5828 net_5827 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5829 net_5821 VSS nch w=3u l=0.1u
M_125 net_5829 net_5821 VDD VDD pch w=4u l=0.1u
M_126 net_5821 net_5829 net_5829 VDD pch w=4u l=0.1u
M_127 net_5798 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5799 net_5830 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5798 net_5829 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5798 net_5799 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5799 net_5798 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5812 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5812 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5805 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5776 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5831 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5785 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5829 ndio area=4p
D_139 VSS net_5821 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5832 net_5809 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5832 net_5809 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5827 net_5817 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5827 net_5817 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5807 net_5814 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5807 net_5814 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5825 net_5832 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5825 net_5832 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5808 net_5822 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5808 net_5822 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5810 I VSS VSS nch w=3u l=0.09u
M_152 net_5810 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5818 net_5821 VSS VSS nch w=3u l=0.09u
M_154 net_5818 net_5821 VDD VDD pch w=7.5u l=0.09u
M_155 net_5830 net_5829 VSS VSS nch w=3u l=0.09u
M_156 net_5830 net_5829 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5833 net_5834 VSS nch w=20u l=0.09u
M_158 VSS net_5835 net_5833 VSS nch w=10u l=0.09u
M_159 VDD net_5833 net_5834 VDD pch w=30u l=0.09u
M_160 VDD net_5835 net_5833 VDD pch w=10u l=0.09u
M_161 VSS net_5803 net_5836 VSS nch_25od w=0.6u l=0.5u
M_162 net_5835 net_5836 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5837 net_5827 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5838 net_5831 net_5837 VSS nch_25od w=10u l=0.5u
M_165 net_5784 net_5831 net_5826 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5803 net_5835 VSS nch_25od w=5u l=0.5u
M_167 net_5805 net_5831 net_5839 VSS nch_25od w=30u l=0.5u
M_168 net_5840 net_5831 net_5838 VSS nch_25od w=10u l=0.5u
M_169 net_5839 net_5808 net_5840 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5803 net_5836 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5838 net_5831 net_5805 net_5783 pch_25od w=26u l=0.415u
M_172 net_5784 net_5838 net_5826 net_5783 pch_25od w=26u l=0.415u
M_173 VDD net_5803 net_5835 VDD pch_25od w=5u l=0.415u
M_174 net_5783 net_5838 VDDPST net_5783 pch_25od w=24u l=0.415u
M_175 net_5783 net_5831 net_5805 net_5783 pch_25od w=24u l=0.415u
M_176 net_5784 net_5831 net_5805 net_5783 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRO16CDG
.SUBCKT PRO24CDG PAD I
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5841 net_5842 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5843 net_5844 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5845 net_5846 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5842 net_5842 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5847 net_5847 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5843 net_5843 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5847 net_5843 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5844 net_5844 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5844 net_5844 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5844 net_5844 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5842 net_5847 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5846 net_5841 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_14 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_15 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_16 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_17 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_18 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_19 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_20 net_5848 net_5848 rppolywo w=0.4u l=1.3u m=1
X_21 net_5849 net_5849 rppolywo w=0.4u l=1.3u m=1
X_22 net_5849 net_5849 rppolywo w=0.4u l=1.3u m=1
X_23 net_5850 net_5850 rppolywo w=0.4u l=1.3u m=1
X_24 net_5850 net_5850 rppolywo w=0.4u l=1.3u m=1
X_25 net_5850 net_5850 rppolywo w=0.4u l=1.3u m=1
X_26 net_5851 net_5848 rppolywo w=0.4u l=1.3u m=1
X_27 net_5848 net_5849 rppolywo w=0.4u l=1.3u m=1
X_28 net_5849 net_5850 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5852 net_5853 VSS nch_25od w=33u l=0.5u
M_30 net_5854 net_5847 VSS VSS nch_25od w=33u l=0.5u
M_31 net_5855 net_5847 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_5852 net_5854 VSS nch_25od w=33u l=0.5u
M_33 PAD net_5852 net_5855 VSS nch_25od w=33u l=0.5u
M_34 net_5856 net_5844 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5857 net_5844 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5858 net_5844 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5853 net_5846 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_5852 net_5856 VSS nch_25od w=33u l=0.5u
M_39 PAD net_5852 net_5857 VSS nch_25od w=33u l=0.5u
M_40 PAD net_5852 net_5858 VSS nch_25od w=33u l=0.5u
M_41 PAD net_5852 net_5859 VSS nch_25od w=33u l=0.5u
M_42 PAD net_5852 net_5860 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5852 net_5861 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5852 net_5862 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5852 net_5863 VSS nch_25od w=33u l=0.5u
M_46 net_5862 net_5842 VSS VSS nch_25od w=33u l=0.5u
M_47 net_5863 net_5842 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_5852 net_5864 VSS nch_25od w=33u l=0.5u
M_49 net_5859 net_5843 VSS VSS nch_25od w=33u l=0.5u
M_50 net_5860 net_5843 VSS VSS nch_25od w=33u l=0.5u
M_51 net_5861 net_5843 VSS VSS nch_25od w=33u l=0.5u
M_52 net_5864 net_5841 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_54 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_55 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_56 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_57 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_58 PAD net_5849 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_59 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_60 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_61 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_62 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_63 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_64 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_65 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_66 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_67 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_68 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_69 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_70 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_71 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_72 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_73 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_74 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_75 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_76 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_77 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_78 PAD net_5848 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_79 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_80 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_81 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_82 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_83 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_84 PAD net_5850 VDDPST net_5865 pch_25od w=16.5u l=0.415u
M_85 VSS net_5866 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5865 net_5865 net_5865 net_5865 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5867 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_5868 net_5868 VSS nch_25od w=2.1u l=0.5u
M_89 net_5869 net_5870 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5871 net_5870 net_5869 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_5868 net_5870 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5871 net_5870 net_5872 VDDPST pch_25od w=5u l=0.415u
M_93 net_5872 net_5873 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5874 net_5875 net_5845 VDDPST pch_25od w=20u l=0.415u
M_95 net_5874 net_5876 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5845 net_5876 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5875 net_5845 VSS nch_25od w=15u l=0.5u
M_98 net_5877 net_5878 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5879 net_5880 net_5881 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5882 VSS nch_25od w=10u l=0.5u
M_101 net_5883 net_5880 net_5884 VSS nch_25od w=10u l=0.5u
M_102 net_5882 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5882 net_5877 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5882 net_5877 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5884 VSS nch w=10u l=0.09u
M_106 net_5879 net_5878 VSS VSS nch w=10u l=0.09u
M_107 net_5883 I net_5882 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5877 net_5878 net_5881 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5885 net_5886 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5887 net_5880 net_5888 VSS nch_25od w=10u l=0.5u
M_111 VSS net_5889 net_5890 VSS nch_25od w=10u l=0.5u
M_112 net_5891 net_5880 net_5892 VSS nch_25od w=10u l=0.5u
M_113 net_5890 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5890 net_5885 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5890 net_5885 VDDPST pch_25od w=3.5u l=1u
M_116 VSS net_5889 net_5892 VSS nch w=10u l=0.09u
M_117 net_5887 net_5886 VSS VSS nch w=10u l=0.09u
M_118 net_5891 net_5889 net_5890 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5885 net_5886 net_5888 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5893 net_5894 VDDPST pch_25od w=40u l=0.415u
M_121 net_5894 net_5895 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5896 net_5893 net_5894 VSS nch_25od w=20u l=0.5u
M_123 net_5896 net_5895 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5897 net_5889 VSS nch w=3u l=0.1u
M_125 net_5897 net_5889 VDD VDD pch w=4u l=0.1u
M_126 net_5889 net_5897 net_5897 VDD pch w=4u l=0.1u
M_127 net_5866 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5867 net_5898 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5866 net_5897 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5866 net_5867 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5867 net_5866 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5880 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5880 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5873 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5899 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5900 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5852 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5897 ndio area=4p
D_139 VSS net_5889 ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5901 net_5877 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5901 net_5877 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5895 net_5885 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5895 net_5885 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5875 net_5882 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5875 net_5882 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5893 net_5901 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5893 net_5901 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5876 net_5890 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5876 net_5890 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5878 I VSS VSS nch w=3u l=0.09u
M_152 net_5878 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5886 net_5889 VSS VSS nch w=3u l=0.09u
M_154 net_5886 net_5889 VDD VDD pch w=7.5u l=0.09u
M_155 net_5898 net_5897 VSS VSS nch w=3u l=0.09u
M_156 net_5898 net_5897 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5902 net_5903 VSS nch w=20u l=0.09u
M_158 VSS net_5904 net_5902 VSS nch w=10u l=0.09u
M_159 VDD net_5902 net_5903 VDD pch w=30u l=0.09u
M_160 VDD net_5904 net_5902 VDD pch w=10u l=0.09u
M_161 VSS net_5871 net_5905 VSS nch_25od w=0.6u l=0.5u
M_162 net_5904 net_5905 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5906 net_5895 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5907 net_5900 net_5906 VSS nch_25od w=10u l=0.5u
M_165 net_5851 net_5900 net_5894 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5871 net_5904 VSS nch_25od w=5u l=0.5u
M_167 net_5873 net_5900 net_5908 VSS nch_25od w=30u l=0.5u
M_168 net_5909 net_5900 net_5907 VSS nch_25od w=10u l=0.5u
M_169 net_5908 net_5876 net_5909 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5871 net_5905 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5907 net_5900 net_5873 net_5865 pch_25od w=26u l=0.415u
M_172 net_5851 net_5907 net_5894 net_5865 pch_25od w=26u l=0.415u
M_173 VDD net_5871 net_5904 VDD pch_25od w=5u l=0.415u
M_174 net_5865 net_5907 VDDPST net_5865 pch_25od w=24u l=0.415u
M_175 net_5865 net_5900 net_5873 net_5865 pch_25od w=24u l=0.415u
M_176 net_5851 net_5900 net_5873 net_5865 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRO24CDG
.SUBCKT PRT08DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5910 net_5911 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5912 net_5912 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5911 net_5913 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5914 net_5910 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5915 net_5914 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5916 net_5916 rppolywo w=0.4u l=1.3u m=1
X_14 net_5917 net_5917 rppolywo w=0.4u l=1.3u m=1
X_15 net_5918 net_5918 rppolywo w=0.4u l=1.3u m=1
X_16 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_17 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_18 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_19 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_20 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_21 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_22 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_23 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_24 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_25 net_5919 net_5919 rppolywo w=0.4u l=1.3u m=1
X_26 net_5920 net_5916 rppolywo w=0.4u l=1.3u m=1
X_27 net_5916 net_5917 rppolywo w=0.4u l=1.3u m=1
X_28 net_5917 net_5918 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5921 net_5922 VSS nch_25od w=33u l=0.5u
M_30 PAD net_5921 net_5923 VSS nch_25od w=33u l=0.5u
M_31 net_5923 net_5914 VSS VSS nch_25od w=33u l=0.5u
M_32 net_5922 net_5911 VSS VSS nch_25od w=33u l=0.5u
M_33 net_5924 net_5910 VSS VSS nch_25od w=33u l=0.5u
M_34 net_5925 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_35 net_5926 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_36 net_5927 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_37 net_5928 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5929 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5930 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5931 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5932 net_5912 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_5921 net_5925 VSS nch_25od w=33u l=0.5u
M_43 PAD net_5921 net_5926 VSS nch_25od w=33u l=0.5u
M_44 PAD net_5921 net_5927 VSS nch_25od w=33u l=0.5u
M_45 PAD net_5921 net_5928 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5921 net_5929 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5921 net_5930 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5921 net_5931 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5921 net_5932 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5921 net_5924 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5921 net_5933 VSS nch_25od w=33u l=0.5u
M_52 net_5933 net_5913 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5916 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_54 PAD net_5916 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_55 PAD net_5916 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_56 PAD net_5916 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_57 PAD net_5917 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_58 PAD net_5917 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_59 PAD net_5917 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_60 PAD net_5917 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_61 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_62 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_63 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_64 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_65 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_66 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_67 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_68 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_69 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_70 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_71 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_72 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_73 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_74 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_75 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_76 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_77 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_78 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_79 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_80 PAD net_5919 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_81 PAD net_5918 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_82 PAD net_5918 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_83 PAD net_5918 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_84 PAD net_5918 VDDPST net_5919 pch_25od w=16.5u l=0.415u
M_85 VSS net_5934 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5919 net_5919 net_5919 net_5919 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_5935 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_5936 net_5936 VSS nch_25od w=2.1u l=0.5u
M_89 net_5937 net_5938 VSS VSS nch_25od w=5u l=0.5u
M_90 net_5939 net_5938 net_5937 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_5936 net_5938 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_5939 net_5938 net_5940 VDDPST pch_25od w=5u l=0.415u
M_93 net_5940 net_5941 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_5942 net_5943 net_5915 VDDPST pch_25od w=20u l=0.415u
M_95 net_5942 net_5944 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5915 net_5944 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_5943 net_5915 VSS nch_25od w=15u l=0.5u
M_98 net_5945 net_5946 VSS VSS nch_25od w=10u l=0.5u
M_99 net_5947 net_5948 net_5949 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_5950 VSS nch_25od w=10u l=0.5u
M_101 net_5951 net_5948 net_5952 VSS nch_25od w=10u l=0.5u
M_102 net_5950 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_5950 net_5945 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_5950 net_5945 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_5952 VSS nch w=10u l=0.09u
M_106 net_5947 net_5946 VSS VSS nch w=10u l=0.09u
M_107 net_5951 I net_5950 VSS nch_na25 w=5.5u l=1.32u
M_108 net_5945 net_5946 net_5949 VSS nch_na25 w=5.5u l=1.32u
M_109 net_5953 net_5954 VSS VSS nch_25od w=10u l=0.5u
M_110 net_5955 net_5948 net_5956 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_5957 VSS nch_25od w=10u l=0.5u
M_112 net_5958 net_5948 net_5959 VSS nch_25od w=10u l=0.5u
M_113 net_5957 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_5957 net_5953 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_5957 net_5953 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_5959 VSS nch w=10u l=0.09u
M_117 net_5955 net_5954 VSS VSS nch w=10u l=0.09u
M_118 net_5958 OEN net_5957 VSS nch_na25 w=5.5u l=1.32u
M_119 net_5953 net_5954 net_5956 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_5960 net_5961 VDDPST pch_25od w=40u l=0.415u
M_121 net_5961 net_5962 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_5963 net_5960 net_5961 VSS nch_25od w=20u l=0.5u
M_123 net_5963 net_5962 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_5964 net_5965 VSS nch w=3u l=0.1u
M_125 net_5964 net_5965 VDD VDD pch w=4u l=0.1u
M_126 net_5965 net_5964 net_5964 VDD pch w=4u l=0.1u
M_127 net_5934 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_5935 net_5966 VSS VSS nch_25od w=20u l=0.5u
M_129 net_5934 net_5964 VSS VSS nch_25od w=20u l=0.5u
M_130 net_5934 net_5935 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_5935 net_5934 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_5948 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_5948 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_5941 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5912 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_5967 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5921 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_5964 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_5968 net_5945 VSS VSS nch_25od w=2u l=0.5u
M_142 net_5968 net_5945 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_5962 net_5953 VSS VSS nch_25od w=3u l=0.5u
M_144 net_5962 net_5953 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_5943 net_5950 VSS VSS nch_25od w=7u l=0.5u
M_146 net_5943 net_5950 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_5960 net_5968 VSS VSS nch_25od w=10u l=0.5u
M_148 net_5960 net_5968 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_5944 net_5957 VSS VSS nch_25od w=3u l=0.5u
M_150 net_5944 net_5957 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_5946 I VSS VSS nch w=3u l=0.09u
M_152 net_5946 I VDD VDD pch w=7.5u l=0.09u
M_153 net_5954 OEN VSS VSS nch w=3u l=0.09u
M_154 net_5954 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_5966 net_5964 VSS VSS nch w=3u l=0.09u
M_156 net_5966 net_5964 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_5969 net_5970 VSS nch w=20u l=0.09u
M_158 VSS net_5971 net_5969 VSS nch w=10u l=0.09u
M_159 VDD net_5969 net_5970 VDD pch w=30u l=0.09u
M_160 VDD net_5971 net_5969 VDD pch w=10u l=0.09u
M_161 VSS net_5939 net_5972 VSS nch_25od w=0.6u l=0.5u
M_162 net_5971 net_5972 VDD VSS nch_25od w=5u l=0.5u
M_163 net_5973 net_5962 VSS VSS nch_25od w=10u l=0.5u
M_164 net_5974 net_5967 net_5973 VSS nch_25od w=10u l=0.5u
M_165 net_5920 net_5967 net_5961 VSS nch_25od w=30u l=0.5u
M_166 VSS net_5939 net_5971 VSS nch_25od w=5u l=0.5u
M_167 net_5941 net_5967 net_5975 VSS nch_25od w=30u l=0.5u
M_168 net_5976 net_5967 net_5974 VSS nch_25od w=10u l=0.5u
M_169 net_5975 net_5944 net_5976 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_5939 net_5972 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_5974 net_5967 net_5941 net_5919 pch_25od w=26u l=0.415u
M_172 net_5920 net_5974 net_5961 net_5919 pch_25od w=26u l=0.415u
M_173 VDD net_5939 net_5971 VDD pch_25od w=5u l=0.415u
M_174 net_5919 net_5974 VDDPST net_5919 pch_25od w=24u l=0.415u
M_175 net_5919 net_5967 net_5941 net_5919 pch_25od w=24u l=0.415u
M_176 net_5920 net_5967 net_5941 net_5919 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRT08DGZ
.SUBCKT PRT12DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_5977 net_5978 rnpolywo w=0.4u l=2.93u m=1
X_2 net_5979 net_5980 rnpolywo w=0.4u l=2.93u m=1
X_3 net_5981 net_5982 rnpolywo w=0.4u l=2.93u m=1
X_4 net_5982 net_5983 rnpolywo w=0.4u l=2.93u m=1
X_5 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_6 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_7 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_8 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_9 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_10 net_5984 net_5984 rnpolywo w=0.4u l=2.93u m=1
X_11 net_5978 net_5981 rnpolywo w=0.4u l=2.93u m=1
X_12 net_5980 net_5977 rnpolywo w=0.4u l=2.93u m=1
X_13 net_5985 net_5985 rppolywo w=0.4u l=1.3u m=1
X_14 net_5985 net_5985 rppolywo w=0.4u l=1.3u m=1
X_15 net_5986 net_5986 rppolywo w=0.4u l=1.3u m=1
X_16 net_5986 net_5986 rppolywo w=0.4u l=1.3u m=1
X_17 net_5987 net_5987 rppolywo w=0.4u l=1.3u m=1
X_18 net_5987 net_5987 rppolywo w=0.4u l=1.3u m=1
X_19 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_20 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_21 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_22 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_23 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_24 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_25 net_5988 net_5988 rppolywo w=0.4u l=1.3u m=1
X_26 net_5989 net_5985 rppolywo w=0.4u l=1.3u m=1
X_27 net_5985 net_5986 rppolywo w=0.4u l=1.3u m=1
X_28 net_5986 net_5987 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_5990 net_5991 VSS nch_25od w=33u l=0.5u
M_30 net_5992 net_5981 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_5990 net_5992 VSS nch_25od w=33u l=0.5u
M_32 net_5991 net_5980 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_5990 net_5993 VSS nch_25od w=33u l=0.5u
M_34 PAD net_5990 net_5994 VSS nch_25od w=33u l=0.5u
M_35 net_5994 net_5978 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_5990 net_5995 VSS nch_25od w=33u l=0.5u
M_37 net_5993 net_5982 VSS VSS nch_25od w=33u l=0.5u
M_38 net_5995 net_5977 VSS VSS nch_25od w=33u l=0.5u
M_39 net_5996 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_40 net_5997 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_41 net_5998 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_42 net_5999 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6000 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6001 net_5984 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_5990 net_5996 VSS nch_25od w=33u l=0.5u
M_46 PAD net_5990 net_5997 VSS nch_25od w=33u l=0.5u
M_47 PAD net_5990 net_5998 VSS nch_25od w=33u l=0.5u
M_48 PAD net_5990 net_5999 VSS nch_25od w=33u l=0.5u
M_49 PAD net_5990 net_6000 VSS nch_25od w=33u l=0.5u
M_50 PAD net_5990 net_6001 VSS nch_25od w=33u l=0.5u
M_51 PAD net_5990 net_6002 VSS nch_25od w=33u l=0.5u
M_52 net_6002 net_5983 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_54 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_55 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_56 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_57 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_58 PAD net_5985 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_59 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_60 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_61 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_62 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_63 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_64 PAD net_5986 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_65 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_66 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_67 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_68 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_69 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_70 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_71 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_72 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_73 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_74 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_75 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_76 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_77 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_78 PAD net_5988 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_79 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_80 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_81 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_82 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_83 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_84 PAD net_5987 VDDPST net_5988 pch_25od w=16.5u l=0.415u
M_85 VSS net_6003 VSS VSS nch_25od w=0.5u l=3u
M_86 net_5988 net_5988 net_5988 net_5988 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_6004 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_6005 net_6005 VSS nch_25od w=2.1u l=0.5u
M_89 net_6006 net_6007 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6008 net_6007 net_6006 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_6005 net_6007 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6008 net_6007 net_6009 VDDPST pch_25od w=5u l=0.415u
M_93 net_6009 net_6010 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6011 net_6012 net_5979 VDDPST pch_25od w=20u l=0.415u
M_95 net_6011 net_6013 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_5979 net_6013 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6012 net_5979 VSS nch_25od w=15u l=0.5u
M_98 net_6014 net_6015 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6016 net_6017 net_6018 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6019 VSS nch_25od w=10u l=0.5u
M_101 net_6020 net_6017 net_6021 VSS nch_25od w=10u l=0.5u
M_102 net_6019 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6019 net_6014 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6019 net_6014 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6021 VSS nch w=10u l=0.09u
M_106 net_6016 net_6015 VSS VSS nch w=10u l=0.09u
M_107 net_6020 I net_6019 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6014 net_6015 net_6018 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6022 net_6023 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6024 net_6017 net_6025 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6026 VSS nch_25od w=10u l=0.5u
M_112 net_6027 net_6017 net_6028 VSS nch_25od w=10u l=0.5u
M_113 net_6026 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6026 net_6022 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6026 net_6022 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6028 VSS nch w=10u l=0.09u
M_117 net_6024 net_6023 VSS VSS nch w=10u l=0.09u
M_118 net_6027 OEN net_6026 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6022 net_6023 net_6025 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6029 net_6030 VDDPST pch_25od w=40u l=0.415u
M_121 net_6030 net_6031 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6032 net_6029 net_6030 VSS nch_25od w=20u l=0.5u
M_123 net_6032 net_6031 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6033 net_6034 VSS nch w=3u l=0.1u
M_125 net_6033 net_6034 VDD VDD pch w=4u l=0.1u
M_126 net_6034 net_6033 net_6033 VDD pch w=4u l=0.1u
M_127 net_6003 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6004 net_6035 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6003 net_6033 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6003 net_6004 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6004 net_6003 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6017 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6017 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6010 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_5984 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6036 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_5990 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6033 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6037 net_6014 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6037 net_6014 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6031 net_6022 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6031 net_6022 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6012 net_6019 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6012 net_6019 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6029 net_6037 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6029 net_6037 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6013 net_6026 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6013 net_6026 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6015 I VSS VSS nch w=3u l=0.09u
M_152 net_6015 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6023 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6023 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6035 net_6033 VSS VSS nch w=3u l=0.09u
M_156 net_6035 net_6033 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6038 net_6039 VSS nch w=20u l=0.09u
M_158 VSS net_6040 net_6038 VSS nch w=10u l=0.09u
M_159 VDD net_6038 net_6039 VDD pch w=30u l=0.09u
M_160 VDD net_6040 net_6038 VDD pch w=10u l=0.09u
M_161 VSS net_6008 net_6041 VSS nch_25od w=0.6u l=0.5u
M_162 net_6040 net_6041 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6042 net_6031 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6043 net_6036 net_6042 VSS nch_25od w=10u l=0.5u
M_165 net_5989 net_6036 net_6030 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6008 net_6040 VSS nch_25od w=5u l=0.5u
M_167 net_6010 net_6036 net_6044 VSS nch_25od w=30u l=0.5u
M_168 net_6045 net_6036 net_6043 VSS nch_25od w=10u l=0.5u
M_169 net_6044 net_6013 net_6045 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6008 net_6041 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6043 net_6036 net_6010 net_5988 pch_25od w=26u l=0.415u
M_172 net_5989 net_6043 net_6030 net_5988 pch_25od w=26u l=0.415u
M_173 VDD net_6008 net_6040 VDD pch_25od w=5u l=0.415u
M_174 net_5988 net_6043 VDDPST net_5988 pch_25od w=24u l=0.415u
M_175 net_5988 net_6036 net_6010 net_5988 pch_25od w=24u l=0.415u
M_176 net_5989 net_6036 net_6010 net_5988 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRT12DGZ
.SUBCKT PRT16DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6046 net_6047 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6048 net_6049 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6050 net_6050 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6050 net_6050 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6050 net_6050 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6050 net_6050 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6051 net_6052 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6052 net_6053 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6053 net_6053 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6052 net_6052 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6047 net_6051 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6049 net_6046 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6054 net_6054 rppolywo w=0.4u l=1.3u m=1
X_14 net_6054 net_6054 rppolywo w=0.4u l=1.3u m=1
X_15 net_6054 net_6054 rppolywo w=0.4u l=1.3u m=1
X_16 net_6055 net_6055 rppolywo w=0.4u l=1.3u m=1
X_17 net_6055 net_6055 rppolywo w=0.4u l=1.3u m=1
X_18 net_6055 net_6055 rppolywo w=0.4u l=1.3u m=1
X_19 net_6056 net_6056 rppolywo w=0.4u l=1.3u m=1
X_20 net_6056 net_6056 rppolywo w=0.4u l=1.3u m=1
X_21 net_6056 net_6056 rppolywo w=0.4u l=1.3u m=1
X_22 net_6057 net_6057 rppolywo w=0.4u l=1.3u m=1
X_23 net_6057 net_6057 rppolywo w=0.4u l=1.3u m=1
X_24 net_6057 net_6057 rppolywo w=0.4u l=1.3u m=1
X_25 net_6057 net_6057 rppolywo w=0.4u l=1.3u m=1
X_26 net_6058 net_6055 rppolywo w=0.4u l=1.3u m=1
X_27 net_6055 net_6054 rppolywo w=0.4u l=1.3u m=1
X_28 net_6054 net_6056 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6059 net_6060 VSS nch_25od w=33u l=0.5u
M_30 net_6061 net_6051 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6059 net_6061 VSS nch_25od w=33u l=0.5u
M_32 net_6060 net_6049 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6059 net_6062 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6059 net_6063 VSS nch_25od w=33u l=0.5u
M_35 PAD net_6059 net_6064 VSS nch_25od w=33u l=0.5u
M_36 net_6064 net_6047 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_6059 net_6065 VSS nch_25od w=33u l=0.5u
M_38 net_6062 net_6052 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6063 net_6052 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6065 net_6046 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6066 net_6050 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6067 net_6050 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6068 net_6050 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6069 net_6050 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6059 net_6066 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6059 net_6067 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6059 net_6068 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6059 net_6069 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6059 net_6070 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6059 net_6071 VSS nch_25od w=33u l=0.5u
M_51 net_6070 net_6053 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6071 net_6053 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_54 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_55 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_56 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_57 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_58 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_59 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_60 PAD net_6054 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_61 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_62 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_63 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_64 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_65 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_66 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_67 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_68 PAD net_6055 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_69 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_70 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_71 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_72 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_73 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_74 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_75 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_76 PAD net_6057 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_77 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_78 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_79 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_80 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_81 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_82 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_83 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_84 PAD net_6056 VDDPST net_6057 pch_25od w=16.5u l=0.415u
M_85 VSS net_6072 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6057 net_6057 net_6057 net_6057 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_6073 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_6074 net_6074 VSS nch_25od w=2.1u l=0.5u
M_89 net_6075 net_6076 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6077 net_6076 net_6075 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_6074 net_6076 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6077 net_6076 net_6078 VDDPST pch_25od w=5u l=0.415u
M_93 net_6078 net_6079 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6080 net_6081 net_6048 VDDPST pch_25od w=20u l=0.415u
M_95 net_6080 net_6082 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6048 net_6082 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6081 net_6048 VSS nch_25od w=15u l=0.5u
M_98 net_6083 net_6084 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6085 net_6086 net_6087 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6088 VSS nch_25od w=10u l=0.5u
M_101 net_6089 net_6086 net_6090 VSS nch_25od w=10u l=0.5u
M_102 net_6088 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6088 net_6083 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6088 net_6083 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6090 VSS nch w=10u l=0.09u
M_106 net_6085 net_6084 VSS VSS nch w=10u l=0.09u
M_107 net_6089 I net_6088 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6083 net_6084 net_6087 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6091 net_6092 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6093 net_6086 net_6094 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6095 VSS nch_25od w=10u l=0.5u
M_112 net_6096 net_6086 net_6097 VSS nch_25od w=10u l=0.5u
M_113 net_6095 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6095 net_6091 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6095 net_6091 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6097 VSS nch w=10u l=0.09u
M_117 net_6093 net_6092 VSS VSS nch w=10u l=0.09u
M_118 net_6096 OEN net_6095 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6091 net_6092 net_6094 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6098 net_6099 VDDPST pch_25od w=40u l=0.415u
M_121 net_6099 net_6100 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6101 net_6098 net_6099 VSS nch_25od w=20u l=0.5u
M_123 net_6101 net_6100 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6102 net_6103 VSS nch w=3u l=0.1u
M_125 net_6102 net_6103 VDD VDD pch w=4u l=0.1u
M_126 net_6103 net_6102 net_6102 VDD pch w=4u l=0.1u
M_127 net_6072 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6073 net_6104 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6072 net_6102 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6072 net_6073 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6073 net_6072 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6086 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6086 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6079 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6050 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6105 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6059 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6102 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6106 net_6083 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6106 net_6083 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6100 net_6091 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6100 net_6091 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6081 net_6088 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6081 net_6088 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6098 net_6106 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6098 net_6106 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6082 net_6095 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6082 net_6095 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6084 I VSS VSS nch w=3u l=0.09u
M_152 net_6084 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6092 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6092 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6104 net_6102 VSS VSS nch w=3u l=0.09u
M_156 net_6104 net_6102 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6107 net_6108 VSS nch w=20u l=0.09u
M_158 VSS net_6109 net_6107 VSS nch w=10u l=0.09u
M_159 VDD net_6107 net_6108 VDD pch w=30u l=0.09u
M_160 VDD net_6109 net_6107 VDD pch w=10u l=0.09u
M_161 VSS net_6077 net_6110 VSS nch_25od w=0.6u l=0.5u
M_162 net_6109 net_6110 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6111 net_6100 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6112 net_6105 net_6111 VSS nch_25od w=10u l=0.5u
M_165 net_6058 net_6105 net_6099 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6077 net_6109 VSS nch_25od w=5u l=0.5u
M_167 net_6079 net_6105 net_6113 VSS nch_25od w=30u l=0.5u
M_168 net_6114 net_6105 net_6112 VSS nch_25od w=10u l=0.5u
M_169 net_6113 net_6082 net_6114 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6077 net_6110 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6112 net_6105 net_6079 net_6057 pch_25od w=26u l=0.415u
M_172 net_6058 net_6112 net_6099 net_6057 pch_25od w=26u l=0.415u
M_173 VDD net_6077 net_6109 VDD pch_25od w=5u l=0.415u
M_174 net_6057 net_6112 VDDPST net_6057 pch_25od w=24u l=0.415u
M_175 net_6057 net_6105 net_6079 net_6057 pch_25od w=24u l=0.415u
M_176 net_6058 net_6105 net_6079 net_6057 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRT16DGZ
.SUBCKT PRT24DGZ PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6115 net_6116 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6117 net_6118 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6119 net_6120 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6116 net_6116 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6121 net_6121 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6117 net_6117 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6121 net_6117 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6118 net_6118 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6118 net_6118 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6118 net_6118 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6116 net_6121 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6120 net_6115 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_14 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_15 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_16 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_17 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_18 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_19 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_20 net_6122 net_6122 rppolywo w=0.4u l=1.3u m=1
X_21 net_6123 net_6123 rppolywo w=0.4u l=1.3u m=1
X_22 net_6123 net_6123 rppolywo w=0.4u l=1.3u m=1
X_23 net_6124 net_6124 rppolywo w=0.4u l=1.3u m=1
X_24 net_6124 net_6124 rppolywo w=0.4u l=1.3u m=1
X_25 net_6124 net_6124 rppolywo w=0.4u l=1.3u m=1
X_26 net_6125 net_6122 rppolywo w=0.4u l=1.3u m=1
X_27 net_6122 net_6123 rppolywo w=0.4u l=1.3u m=1
X_28 net_6123 net_6124 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6126 net_6127 VSS nch_25od w=33u l=0.5u
M_30 net_6128 net_6121 VSS VSS nch_25od w=33u l=0.5u
M_31 net_6129 net_6121 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_6126 net_6128 VSS nch_25od w=33u l=0.5u
M_33 PAD net_6126 net_6129 VSS nch_25od w=33u l=0.5u
M_34 net_6130 net_6118 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6131 net_6118 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6132 net_6118 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6127 net_6120 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_6126 net_6130 VSS nch_25od w=33u l=0.5u
M_39 PAD net_6126 net_6131 VSS nch_25od w=33u l=0.5u
M_40 PAD net_6126 net_6132 VSS nch_25od w=33u l=0.5u
M_41 PAD net_6126 net_6133 VSS nch_25od w=33u l=0.5u
M_42 PAD net_6126 net_6134 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6126 net_6135 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6126 net_6136 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6126 net_6137 VSS nch_25od w=33u l=0.5u
M_46 net_6136 net_6116 VSS VSS nch_25od w=33u l=0.5u
M_47 net_6137 net_6116 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_6126 net_6138 VSS nch_25od w=33u l=0.5u
M_49 net_6133 net_6117 VSS VSS nch_25od w=33u l=0.5u
M_50 net_6134 net_6117 VSS VSS nch_25od w=33u l=0.5u
M_51 net_6135 net_6117 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6138 net_6115 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_54 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_55 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_56 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_57 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_58 PAD net_6123 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_59 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_60 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_61 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_62 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_63 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_64 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_65 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_66 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_67 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_68 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_69 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_70 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_71 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_72 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_73 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_74 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_75 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_76 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_77 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_78 PAD net_6122 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_79 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_80 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_81 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_82 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_83 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_84 PAD net_6124 VDDPST net_6139 pch_25od w=16.5u l=0.415u
M_85 VSS net_6140 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6139 net_6139 net_6139 net_6139 pch_25od w=0.5u l=0.9u
M_87 VDDPST net_6141 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS net_6142 net_6142 VSS nch_25od w=2.1u l=0.5u
M_89 net_6143 net_6144 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6145 net_6144 net_6143 VSS nch_25od w=5u l=0.5u
M_91 VDDPST net_6142 net_6144 VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6145 net_6144 net_6146 VDDPST pch_25od w=5u l=0.415u
M_93 net_6146 net_6147 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6148 net_6149 net_6119 VDDPST pch_25od w=20u l=0.415u
M_95 net_6148 net_6150 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6119 net_6150 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6149 net_6119 VSS nch_25od w=15u l=0.5u
M_98 net_6151 net_6152 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6153 net_6154 net_6155 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6156 VSS nch_25od w=10u l=0.5u
M_101 net_6157 net_6154 net_6158 VSS nch_25od w=10u l=0.5u
M_102 net_6156 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6156 net_6151 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6156 net_6151 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6158 VSS nch w=10u l=0.09u
M_106 net_6153 net_6152 VSS VSS nch w=10u l=0.09u
M_107 net_6157 I net_6156 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6151 net_6152 net_6155 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6159 net_6160 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6161 net_6154 net_6162 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6163 VSS nch_25od w=10u l=0.5u
M_112 net_6164 net_6154 net_6165 VSS nch_25od w=10u l=0.5u
M_113 net_6163 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6163 net_6159 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6163 net_6159 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6165 VSS nch w=10u l=0.09u
M_117 net_6161 net_6160 VSS VSS nch w=10u l=0.09u
M_118 net_6164 OEN net_6163 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6159 net_6160 net_6162 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6166 net_6167 VDDPST pch_25od w=40u l=0.415u
M_121 net_6167 net_6168 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6169 net_6166 net_6167 VSS nch_25od w=20u l=0.5u
M_123 net_6169 net_6168 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6170 net_6171 VSS nch w=3u l=0.1u
M_125 net_6170 net_6171 VDD VDD pch w=4u l=0.1u
M_126 net_6171 net_6170 net_6170 VDD pch w=4u l=0.1u
M_127 net_6140 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6141 net_6172 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6140 net_6170 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6140 net_6141 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6141 net_6140 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6154 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6154 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6147 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6173 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6174 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6126 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6170 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6175 net_6151 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6175 net_6151 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6168 net_6159 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6168 net_6159 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6149 net_6156 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6149 net_6156 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6166 net_6175 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6166 net_6175 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6150 net_6163 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6150 net_6163 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6152 I VSS VSS nch w=3u l=0.09u
M_152 net_6152 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6160 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6160 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6172 net_6170 VSS VSS nch w=3u l=0.09u
M_156 net_6172 net_6170 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6176 net_6177 VSS nch w=20u l=0.09u
M_158 VSS net_6178 net_6176 VSS nch w=10u l=0.09u
M_159 VDD net_6176 net_6177 VDD pch w=30u l=0.09u
M_160 VDD net_6178 net_6176 VDD pch w=10u l=0.09u
M_161 VSS net_6145 net_6179 VSS nch_25od w=0.6u l=0.5u
M_162 net_6178 net_6179 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6180 net_6168 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6181 net_6174 net_6180 VSS nch_25od w=10u l=0.5u
M_165 net_6125 net_6174 net_6167 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6145 net_6178 VSS nch_25od w=5u l=0.5u
M_167 net_6147 net_6174 net_6182 VSS nch_25od w=30u l=0.5u
M_168 net_6183 net_6174 net_6181 VSS nch_25od w=10u l=0.5u
M_169 net_6182 net_6150 net_6183 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6145 net_6179 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6181 net_6174 net_6147 net_6139 pch_25od w=26u l=0.415u
M_172 net_6125 net_6181 net_6167 net_6139 pch_25od w=26u l=0.415u
M_173 VDD net_6145 net_6178 VDD pch_25od w=5u l=0.415u
M_174 net_6139 net_6181 VDDPST net_6139 pch_25od w=24u l=0.415u
M_175 net_6139 net_6174 net_6147 net_6139 pch_25od w=24u l=0.415u
M_176 net_6125 net_6174 net_6147 net_6139 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRT24DGZ
.SUBCKT PRU08DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6184 net_6185 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6186 net_6186 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6185 net_6187 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6188 net_6184 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6189 net_6188 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6190 net_6190 rppolywo w=0.4u l=1.3u m=1
X_14 net_6191 net_6191 rppolywo w=0.4u l=1.3u m=1
X_15 net_6192 net_6192 rppolywo w=0.4u l=1.3u m=1
X_16 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_17 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_18 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_19 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_20 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_21 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_22 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_23 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_24 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_25 net_6193 net_6193 rppolywo w=0.4u l=1.3u m=1
X_26 net_6194 net_6190 rppolywo w=0.4u l=1.3u m=1
X_27 net_6190 net_6191 rppolywo w=0.4u l=1.3u m=1
X_28 net_6191 net_6192 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6195 net_6196 VSS nch_25od w=33u l=0.5u
M_30 PAD net_6195 net_6197 VSS nch_25od w=33u l=0.5u
M_31 net_6197 net_6188 VSS VSS nch_25od w=33u l=0.5u
M_32 net_6196 net_6185 VSS VSS nch_25od w=33u l=0.5u
M_33 net_6198 net_6184 VSS VSS nch_25od w=33u l=0.5u
M_34 net_6199 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6200 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6201 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6202 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6203 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6204 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6205 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6206 net_6186 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_6195 net_6199 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6195 net_6200 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6195 net_6201 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6195 net_6202 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6195 net_6203 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6195 net_6204 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6195 net_6205 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6195 net_6206 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6195 net_6198 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6195 net_6207 VSS nch_25od w=33u l=0.5u
M_52 net_6207 net_6187 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6190 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_54 PAD net_6190 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_55 PAD net_6190 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_56 PAD net_6190 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_57 PAD net_6191 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_58 PAD net_6191 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_59 PAD net_6191 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_60 PAD net_6191 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_61 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_62 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_63 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_64 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_65 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_66 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_67 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_68 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_69 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_70 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_71 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_72 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_73 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_74 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_75 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_76 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_77 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_78 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_79 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_80 PAD net_6193 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_81 PAD net_6192 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_82 PAD net_6192 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_83 PAD net_6192 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_84 PAD net_6192 VDDPST net_6193 pch_25od w=16.5u l=0.415u
M_85 VSS net_6208 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6193 net_6193 net_6193 net_6193 pch_25od w=0.5u l=0.9u
M_87 net_6209 net_6210 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6211 net_6209 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6212 net_6209 net_6211 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6212 net_6209 net_6213 VDDPST pch_25od w=5u l=0.415u
M_93 net_6213 net_6214 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6215 net_6216 net_6189 VDDPST pch_25od w=20u l=0.415u
M_95 net_6215 net_6217 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6189 net_6217 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6216 net_6189 VSS nch_25od w=15u l=0.5u
M_98 net_6218 net_6219 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6220 net_6221 net_6222 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6223 VSS nch_25od w=10u l=0.5u
M_101 net_6224 net_6221 net_6225 VSS nch_25od w=10u l=0.5u
M_102 net_6223 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6223 net_6218 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6223 net_6218 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6225 VSS nch w=10u l=0.09u
M_106 net_6220 net_6219 VSS VSS nch w=10u l=0.09u
M_107 net_6224 I net_6223 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6218 net_6219 net_6222 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6226 net_6227 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6228 net_6221 net_6229 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6230 VSS nch_25od w=10u l=0.5u
M_112 net_6231 net_6221 net_6232 VSS nch_25od w=10u l=0.5u
M_113 net_6230 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6230 net_6226 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6230 net_6226 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6232 VSS nch w=10u l=0.09u
M_117 net_6228 net_6227 VSS VSS nch w=10u l=0.09u
M_118 net_6231 OEN net_6230 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6226 net_6227 net_6229 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6233 net_6234 VDDPST pch_25od w=40u l=0.415u
M_121 net_6234 net_6235 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6236 net_6233 net_6234 VSS nch_25od w=20u l=0.5u
M_123 net_6236 net_6235 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6237 net_6238 VSS nch w=3u l=0.1u
M_125 net_6237 net_6238 VDD VDD pch w=4u l=0.1u
M_126 net_6238 net_6237 net_6237 VDD pch w=4u l=0.1u
M_127 net_6208 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6210 net_6239 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6208 net_6238 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6208 net_6210 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6210 net_6208 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6221 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6221 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6214 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6186 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6240 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6195 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6238 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6241 net_6218 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6241 net_6218 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6235 net_6226 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6235 net_6226 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6216 net_6223 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6216 net_6223 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6233 net_6241 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6233 net_6241 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6217 net_6230 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6217 net_6230 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6219 I VSS VSS nch w=3u l=0.09u
M_152 net_6219 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6227 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6227 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6239 net_6238 VSS VSS nch w=3u l=0.09u
M_156 net_6239 net_6238 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6242 C VSS nch w=20u l=0.09u
M_158 VSS net_6243 net_6242 VSS nch w=10u l=0.09u
M_159 VDD net_6242 C VDD pch w=30u l=0.09u
M_160 VDD net_6243 net_6242 VDD pch w=10u l=0.09u
M_161 VSS net_6212 net_6244 VSS nch_25od w=0.6u l=0.5u
M_162 net_6243 net_6244 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6245 net_6235 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6246 net_6240 net_6245 VSS nch_25od w=10u l=0.5u
M_165 net_6194 net_6240 net_6234 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6212 net_6243 VSS nch_25od w=5u l=0.5u
M_167 net_6214 net_6240 net_6209 VSS nch_25od w=30u l=0.5u
M_168 net_6247 net_6240 net_6246 VSS nch_25od w=10u l=0.5u
M_169 net_6209 net_6217 net_6247 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6212 net_6244 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6246 net_6240 net_6214 net_6193 pch_25od w=26u l=0.415u
M_172 net_6194 net_6246 net_6234 net_6193 pch_25od w=26u l=0.415u
M_173 VDD net_6212 net_6243 VDD pch_25od w=5u l=0.415u
M_174 net_6193 net_6246 VDDPST net_6193 pch_25od w=24u l=0.415u
M_175 net_6193 net_6240 net_6214 net_6193 pch_25od w=24u l=0.415u
M_176 net_6194 net_6240 net_6214 net_6193 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU08DGZ
.SUBCKT PRU08SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6248 net_6249 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6250 net_6250 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6249 net_6251 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6252 net_6248 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6253 net_6252 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6254 net_6254 rppolywo w=0.4u l=1.3u m=1
X_14 net_6255 net_6255 rppolywo w=0.4u l=1.3u m=1
X_15 net_6256 net_6256 rppolywo w=0.4u l=1.3u m=1
X_16 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_17 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_18 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_19 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_20 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_21 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_22 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_23 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_24 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_25 net_6257 net_6257 rppolywo w=0.4u l=1.3u m=1
X_26 net_6258 net_6254 rppolywo w=0.4u l=1.3u m=1
X_27 net_6254 net_6255 rppolywo w=0.4u l=1.3u m=1
X_28 net_6255 net_6256 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6259 net_6260 VSS nch_25od w=33u l=0.5u
M_30 PAD net_6259 net_6261 VSS nch_25od w=33u l=0.5u
M_31 net_6261 net_6252 VSS VSS nch_25od w=33u l=0.5u
M_32 net_6260 net_6249 VSS VSS nch_25od w=33u l=0.5u
M_33 net_6262 net_6248 VSS VSS nch_25od w=33u l=0.5u
M_34 net_6263 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6264 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6265 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6266 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6267 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6268 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6269 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6270 net_6250 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_6259 net_6263 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6259 net_6264 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6259 net_6265 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6259 net_6266 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6259 net_6267 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6259 net_6268 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6259 net_6269 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6259 net_6270 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6259 net_6262 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6259 net_6271 VSS nch_25od w=33u l=0.5u
M_52 net_6271 net_6251 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6254 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_54 PAD net_6254 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_55 PAD net_6254 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_56 PAD net_6254 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_57 PAD net_6255 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_58 PAD net_6255 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_59 PAD net_6255 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_60 PAD net_6255 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_61 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_62 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_63 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_64 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_65 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_66 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_67 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_68 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_69 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_70 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_71 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_72 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_73 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_74 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_75 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_76 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_77 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_78 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_79 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_80 PAD net_6257 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_81 PAD net_6256 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_82 PAD net_6256 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_83 PAD net_6256 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_84 PAD net_6256 VDDPST net_6257 pch_25od w=16.5u l=0.415u
M_85 VSS net_6272 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6257 net_6257 net_6257 net_6257 pch_25od w=0.5u l=0.9u
M_87 net_6273 net_6274 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_6275 net_6276 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_6275 net_6273 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6276 net_6273 net_6275 VSS nch_25od w=5u l=0.5u
M_91 net_6277 net_6276 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6276 net_6273 net_6277 VDDPST pch_25od w=5u l=0.415u
M_93 net_6277 net_6278 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6279 net_6280 net_6253 VDDPST pch_25od w=20u l=0.415u
M_95 net_6279 net_6281 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6253 net_6281 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6280 net_6253 VSS nch_25od w=15u l=0.5u
M_98 net_6282 net_6283 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6284 net_6285 net_6286 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6287 VSS nch_25od w=10u l=0.5u
M_101 net_6288 net_6285 net_6289 VSS nch_25od w=10u l=0.5u
M_102 net_6287 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6287 net_6282 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6287 net_6282 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6289 VSS nch w=10u l=0.09u
M_106 net_6284 net_6283 VSS VSS nch w=10u l=0.09u
M_107 net_6288 I net_6287 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6282 net_6283 net_6286 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6290 net_6291 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6292 net_6285 net_6293 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6294 VSS nch_25od w=10u l=0.5u
M_112 net_6295 net_6285 net_6296 VSS nch_25od w=10u l=0.5u
M_113 net_6294 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6294 net_6290 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6294 net_6290 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6296 VSS nch w=10u l=0.09u
M_117 net_6292 net_6291 VSS VSS nch w=10u l=0.09u
M_118 net_6295 OEN net_6294 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6290 net_6291 net_6293 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6297 net_6298 VDDPST pch_25od w=40u l=0.415u
M_121 net_6298 net_6299 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6300 net_6297 net_6298 VSS nch_25od w=20u l=0.5u
M_123 net_6300 net_6299 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6301 net_6302 VSS nch w=3u l=0.1u
M_125 net_6301 net_6302 VDD VDD pch w=4u l=0.1u
M_126 net_6302 net_6301 net_6301 VDD pch w=4u l=0.1u
M_127 net_6272 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6274 net_6303 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6272 net_6302 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6272 net_6274 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6274 net_6272 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6285 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6285 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6278 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6250 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6304 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6259 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6302 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6305 net_6282 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6305 net_6282 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6299 net_6290 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6299 net_6290 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6280 net_6287 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6280 net_6287 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6297 net_6305 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6297 net_6305 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6281 net_6294 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6281 net_6294 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6283 I VSS VSS nch w=3u l=0.09u
M_152 net_6283 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6291 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6291 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6303 net_6302 VSS VSS nch w=3u l=0.09u
M_156 net_6303 net_6302 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6306 C VSS nch w=20u l=0.09u
M_158 VSS net_6307 net_6306 VSS nch w=10u l=0.09u
M_159 VDD net_6306 C VDD pch w=30u l=0.09u
M_160 VDD net_6307 net_6306 VDD pch w=10u l=0.09u
M_161 VSS net_6276 net_6308 VSS nch_25od w=0.6u l=0.5u
M_162 net_6307 net_6308 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6309 net_6299 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6310 net_6304 net_6309 VSS nch_25od w=10u l=0.5u
M_165 net_6258 net_6304 net_6298 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6276 net_6307 VSS nch_25od w=5u l=0.5u
M_167 net_6278 net_6304 net_6273 VSS nch_25od w=30u l=0.5u
M_168 net_6311 net_6304 net_6310 VSS nch_25od w=10u l=0.5u
M_169 net_6273 net_6281 net_6311 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6276 net_6308 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6310 net_6304 net_6278 net_6257 pch_25od w=26u l=0.415u
M_172 net_6258 net_6310 net_6298 net_6257 pch_25od w=26u l=0.415u
M_173 VDD net_6276 net_6307 VDD pch_25od w=5u l=0.415u
M_174 net_6257 net_6310 VDDPST net_6257 pch_25od w=24u l=0.415u
M_175 net_6257 net_6304 net_6278 net_6257 pch_25od w=24u l=0.415u
M_176 net_6258 net_6304 net_6278 net_6257 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU08SDGZ
.SUBCKT PRU12DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6312 net_6313 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6314 net_6315 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6316 net_6317 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6317 net_6318 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6319 net_6319 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6313 net_6316 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6315 net_6312 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6320 net_6320 rppolywo w=0.4u l=1.3u m=1
X_14 net_6320 net_6320 rppolywo w=0.4u l=1.3u m=1
X_15 net_6321 net_6321 rppolywo w=0.4u l=1.3u m=1
X_16 net_6321 net_6321 rppolywo w=0.4u l=1.3u m=1
X_17 net_6322 net_6322 rppolywo w=0.4u l=1.3u m=1
X_18 net_6322 net_6322 rppolywo w=0.4u l=1.3u m=1
X_19 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_20 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_21 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_22 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_23 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_24 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_25 net_6323 net_6323 rppolywo w=0.4u l=1.3u m=1
X_26 net_6324 net_6320 rppolywo w=0.4u l=1.3u m=1
X_27 net_6320 net_6321 rppolywo w=0.4u l=1.3u m=1
X_28 net_6321 net_6322 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6325 net_6326 VSS nch_25od w=33u l=0.5u
M_30 net_6327 net_6316 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6325 net_6327 VSS nch_25od w=33u l=0.5u
M_32 net_6326 net_6315 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6325 net_6328 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6325 net_6329 VSS nch_25od w=33u l=0.5u
M_35 net_6329 net_6313 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_6325 net_6330 VSS nch_25od w=33u l=0.5u
M_37 net_6328 net_6317 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6330 net_6312 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6331 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6332 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6333 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6334 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6335 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6336 net_6319 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6325 net_6331 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6325 net_6332 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6325 net_6333 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6325 net_6334 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6325 net_6335 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6325 net_6336 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6325 net_6337 VSS nch_25od w=33u l=0.5u
M_52 net_6337 net_6318 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_54 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_55 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_56 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_57 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_58 PAD net_6320 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_59 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_60 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_61 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_62 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_63 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_64 PAD net_6321 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_65 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_66 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_67 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_68 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_69 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_70 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_71 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_72 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_73 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_74 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_75 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_76 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_77 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_78 PAD net_6323 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_79 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_80 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_81 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_82 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_83 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_84 PAD net_6322 VDDPST net_6323 pch_25od w=16.5u l=0.415u
M_85 VSS net_6338 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6323 net_6323 net_6323 net_6323 pch_25od w=0.5u l=0.9u
M_87 net_6339 net_6340 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6341 net_6339 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6342 net_6339 net_6341 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6342 net_6339 net_6343 VDDPST pch_25od w=5u l=0.415u
M_93 net_6343 net_6344 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6345 net_6346 net_6314 VDDPST pch_25od w=20u l=0.415u
M_95 net_6345 net_6347 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6314 net_6347 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6346 net_6314 VSS nch_25od w=15u l=0.5u
M_98 net_6348 net_6349 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6350 net_6351 net_6352 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6353 VSS nch_25od w=10u l=0.5u
M_101 net_6354 net_6351 net_6355 VSS nch_25od w=10u l=0.5u
M_102 net_6353 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6353 net_6348 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6353 net_6348 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6355 VSS nch w=10u l=0.09u
M_106 net_6350 net_6349 VSS VSS nch w=10u l=0.09u
M_107 net_6354 I net_6353 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6348 net_6349 net_6352 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6356 net_6357 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6358 net_6351 net_6359 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6360 VSS nch_25od w=10u l=0.5u
M_112 net_6361 net_6351 net_6362 VSS nch_25od w=10u l=0.5u
M_113 net_6360 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6360 net_6356 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6360 net_6356 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6362 VSS nch w=10u l=0.09u
M_117 net_6358 net_6357 VSS VSS nch w=10u l=0.09u
M_118 net_6361 OEN net_6360 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6356 net_6357 net_6359 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6363 net_6364 VDDPST pch_25od w=40u l=0.415u
M_121 net_6364 net_6365 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6366 net_6363 net_6364 VSS nch_25od w=20u l=0.5u
M_123 net_6366 net_6365 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6367 net_6368 VSS nch w=3u l=0.1u
M_125 net_6367 net_6368 VDD VDD pch w=4u l=0.1u
M_126 net_6368 net_6367 net_6367 VDD pch w=4u l=0.1u
M_127 net_6338 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6340 net_6369 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6338 net_6368 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6338 net_6340 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6340 net_6338 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6351 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6351 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6344 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6319 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6370 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6325 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6368 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6371 net_6348 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6371 net_6348 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6365 net_6356 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6365 net_6356 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6346 net_6353 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6346 net_6353 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6363 net_6371 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6363 net_6371 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6347 net_6360 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6347 net_6360 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6349 I VSS VSS nch w=3u l=0.09u
M_152 net_6349 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6357 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6357 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6369 net_6368 VSS VSS nch w=3u l=0.09u
M_156 net_6369 net_6368 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6372 C VSS nch w=20u l=0.09u
M_158 VSS net_6373 net_6372 VSS nch w=10u l=0.09u
M_159 VDD net_6372 C VDD pch w=30u l=0.09u
M_160 VDD net_6373 net_6372 VDD pch w=10u l=0.09u
M_161 VSS net_6342 net_6374 VSS nch_25od w=0.6u l=0.5u
M_162 net_6373 net_6374 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6375 net_6365 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6376 net_6370 net_6375 VSS nch_25od w=10u l=0.5u
M_165 net_6324 net_6370 net_6364 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6342 net_6373 VSS nch_25od w=5u l=0.5u
M_167 net_6344 net_6370 net_6339 VSS nch_25od w=30u l=0.5u
M_168 net_6377 net_6370 net_6376 VSS nch_25od w=10u l=0.5u
M_169 net_6339 net_6347 net_6377 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6342 net_6374 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6376 net_6370 net_6344 net_6323 pch_25od w=26u l=0.415u
M_172 net_6324 net_6376 net_6364 net_6323 pch_25od w=26u l=0.415u
M_173 VDD net_6342 net_6373 VDD pch_25od w=5u l=0.415u
M_174 net_6323 net_6376 VDDPST net_6323 pch_25od w=24u l=0.415u
M_175 net_6323 net_6370 net_6344 net_6323 pch_25od w=24u l=0.415u
M_176 net_6324 net_6370 net_6344 net_6323 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU12DGZ
.SUBCKT PRU12SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6378 net_6379 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6380 net_6381 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6382 net_6383 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6383 net_6384 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6385 net_6385 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6379 net_6382 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6381 net_6378 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6386 net_6386 rppolywo w=0.4u l=1.3u m=1
X_14 net_6386 net_6386 rppolywo w=0.4u l=1.3u m=1
X_15 net_6387 net_6387 rppolywo w=0.4u l=1.3u m=1
X_16 net_6387 net_6387 rppolywo w=0.4u l=1.3u m=1
X_17 net_6388 net_6388 rppolywo w=0.4u l=1.3u m=1
X_18 net_6388 net_6388 rppolywo w=0.4u l=1.3u m=1
X_19 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_20 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_21 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_22 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_23 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_24 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_25 net_6389 net_6389 rppolywo w=0.4u l=1.3u m=1
X_26 net_6390 net_6386 rppolywo w=0.4u l=1.3u m=1
X_27 net_6386 net_6387 rppolywo w=0.4u l=1.3u m=1
X_28 net_6387 net_6388 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6391 net_6392 VSS nch_25od w=33u l=0.5u
M_30 net_6393 net_6382 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6391 net_6393 VSS nch_25od w=33u l=0.5u
M_32 net_6392 net_6381 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6391 net_6394 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6391 net_6395 VSS nch_25od w=33u l=0.5u
M_35 net_6395 net_6379 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_6391 net_6396 VSS nch_25od w=33u l=0.5u
M_37 net_6394 net_6383 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6396 net_6378 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6397 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6398 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6399 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6400 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6401 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6402 net_6385 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6391 net_6397 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6391 net_6398 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6391 net_6399 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6391 net_6400 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6391 net_6401 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6391 net_6402 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6391 net_6403 VSS nch_25od w=33u l=0.5u
M_52 net_6403 net_6384 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_54 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_55 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_56 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_57 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_58 PAD net_6386 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_59 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_60 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_61 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_62 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_63 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_64 PAD net_6387 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_65 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_66 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_67 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_68 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_69 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_70 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_71 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_72 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_73 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_74 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_75 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_76 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_77 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_78 PAD net_6389 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_79 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_80 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_81 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_82 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_83 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_84 PAD net_6388 VDDPST net_6389 pch_25od w=16.5u l=0.415u
M_85 VSS net_6404 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6389 net_6389 net_6389 net_6389 pch_25od w=0.5u l=0.9u
M_87 net_6405 net_6406 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_6407 net_6408 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_6407 net_6405 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6408 net_6405 net_6407 VSS nch_25od w=5u l=0.5u
M_91 net_6409 net_6408 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6408 net_6405 net_6409 VDDPST pch_25od w=5u l=0.415u
M_93 net_6409 net_6410 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6411 net_6412 net_6380 VDDPST pch_25od w=20u l=0.415u
M_95 net_6411 net_6413 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6380 net_6413 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6412 net_6380 VSS nch_25od w=15u l=0.5u
M_98 net_6414 net_6415 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6416 net_6417 net_6418 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6419 VSS nch_25od w=10u l=0.5u
M_101 net_6420 net_6417 net_6421 VSS nch_25od w=10u l=0.5u
M_102 net_6419 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6419 net_6414 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6419 net_6414 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6421 VSS nch w=10u l=0.09u
M_106 net_6416 net_6415 VSS VSS nch w=10u l=0.09u
M_107 net_6420 I net_6419 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6414 net_6415 net_6418 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6422 net_6423 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6424 net_6417 net_6425 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6426 VSS nch_25od w=10u l=0.5u
M_112 net_6427 net_6417 net_6428 VSS nch_25od w=10u l=0.5u
M_113 net_6426 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6426 net_6422 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6426 net_6422 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6428 VSS nch w=10u l=0.09u
M_117 net_6424 net_6423 VSS VSS nch w=10u l=0.09u
M_118 net_6427 OEN net_6426 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6422 net_6423 net_6425 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6429 net_6430 VDDPST pch_25od w=40u l=0.415u
M_121 net_6430 net_6431 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6432 net_6429 net_6430 VSS nch_25od w=20u l=0.5u
M_123 net_6432 net_6431 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6433 net_6434 VSS nch w=3u l=0.1u
M_125 net_6433 net_6434 VDD VDD pch w=4u l=0.1u
M_126 net_6434 net_6433 net_6433 VDD pch w=4u l=0.1u
M_127 net_6404 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6406 net_6435 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6404 net_6434 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6404 net_6406 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6406 net_6404 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6417 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6417 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6410 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6385 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6436 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6391 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6434 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6437 net_6414 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6437 net_6414 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6431 net_6422 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6431 net_6422 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6412 net_6419 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6412 net_6419 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6429 net_6437 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6429 net_6437 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6413 net_6426 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6413 net_6426 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6415 I VSS VSS nch w=3u l=0.09u
M_152 net_6415 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6423 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6423 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6435 net_6434 VSS VSS nch w=3u l=0.09u
M_156 net_6435 net_6434 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6438 C VSS nch w=20u l=0.09u
M_158 VSS net_6439 net_6438 VSS nch w=10u l=0.09u
M_159 VDD net_6438 C VDD pch w=30u l=0.09u
M_160 VDD net_6439 net_6438 VDD pch w=10u l=0.09u
M_161 VSS net_6408 net_6440 VSS nch_25od w=0.6u l=0.5u
M_162 net_6439 net_6440 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6441 net_6431 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6442 net_6436 net_6441 VSS nch_25od w=10u l=0.5u
M_165 net_6390 net_6436 net_6430 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6408 net_6439 VSS nch_25od w=5u l=0.5u
M_167 net_6410 net_6436 net_6405 VSS nch_25od w=30u l=0.5u
M_168 net_6443 net_6436 net_6442 VSS nch_25od w=10u l=0.5u
M_169 net_6405 net_6413 net_6443 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6408 net_6440 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6442 net_6436 net_6410 net_6389 pch_25od w=26u l=0.415u
M_172 net_6390 net_6442 net_6430 net_6389 pch_25od w=26u l=0.415u
M_173 VDD net_6408 net_6439 VDD pch_25od w=5u l=0.415u
M_174 net_6389 net_6442 VDDPST net_6389 pch_25od w=24u l=0.415u
M_175 net_6389 net_6436 net_6410 net_6389 pch_25od w=24u l=0.415u
M_176 net_6390 net_6436 net_6410 net_6389 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU12SDGZ
.SUBCKT PRU16DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6444 net_6445 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6446 net_6447 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6448 net_6448 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6448 net_6448 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6448 net_6448 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6448 net_6448 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6449 net_6450 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6450 net_6451 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6451 net_6451 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6450 net_6450 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6445 net_6449 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6447 net_6444 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6452 net_6452 rppolywo w=0.4u l=1.3u m=1
X_14 net_6452 net_6452 rppolywo w=0.4u l=1.3u m=1
X_15 net_6452 net_6452 rppolywo w=0.4u l=1.3u m=1
X_16 net_6453 net_6453 rppolywo w=0.4u l=1.3u m=1
X_17 net_6453 net_6453 rppolywo w=0.4u l=1.3u m=1
X_18 net_6453 net_6453 rppolywo w=0.4u l=1.3u m=1
X_19 net_6454 net_6454 rppolywo w=0.4u l=1.3u m=1
X_20 net_6454 net_6454 rppolywo w=0.4u l=1.3u m=1
X_21 net_6454 net_6454 rppolywo w=0.4u l=1.3u m=1
X_22 net_6455 net_6455 rppolywo w=0.4u l=1.3u m=1
X_23 net_6455 net_6455 rppolywo w=0.4u l=1.3u m=1
X_24 net_6455 net_6455 rppolywo w=0.4u l=1.3u m=1
X_25 net_6455 net_6455 rppolywo w=0.4u l=1.3u m=1
X_26 net_6456 net_6453 rppolywo w=0.4u l=1.3u m=1
X_27 net_6453 net_6452 rppolywo w=0.4u l=1.3u m=1
X_28 net_6452 net_6454 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6457 net_6458 VSS nch_25od w=33u l=0.5u
M_30 net_6459 net_6449 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6457 net_6459 VSS nch_25od w=33u l=0.5u
M_32 net_6458 net_6447 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6457 net_6460 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6457 net_6461 VSS nch_25od w=33u l=0.5u
M_35 PAD net_6457 net_6462 VSS nch_25od w=33u l=0.5u
M_36 net_6462 net_6445 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_6457 net_6463 VSS nch_25od w=33u l=0.5u
M_38 net_6460 net_6450 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6461 net_6450 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6463 net_6444 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6464 net_6448 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6465 net_6448 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6466 net_6448 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6467 net_6448 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6457 net_6464 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6457 net_6465 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6457 net_6466 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6457 net_6467 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6457 net_6468 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6457 net_6469 VSS nch_25od w=33u l=0.5u
M_51 net_6468 net_6451 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6469 net_6451 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_54 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_55 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_56 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_57 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_58 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_59 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_60 PAD net_6452 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_61 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_62 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_63 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_64 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_65 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_66 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_67 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_68 PAD net_6453 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_69 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_70 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_71 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_72 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_73 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_74 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_75 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_76 PAD net_6455 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_77 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_78 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_79 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_80 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_81 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_82 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_83 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_84 PAD net_6454 VDDPST net_6455 pch_25od w=16.5u l=0.415u
M_85 VSS net_6470 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6455 net_6455 net_6455 net_6455 pch_25od w=0.5u l=0.9u
M_87 net_6471 net_6472 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6473 net_6471 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6474 net_6471 net_6473 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6474 net_6471 net_6475 VDDPST pch_25od w=5u l=0.415u
M_93 net_6475 net_6476 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6477 net_6478 net_6446 VDDPST pch_25od w=20u l=0.415u
M_95 net_6477 net_6479 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6446 net_6479 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6478 net_6446 VSS nch_25od w=15u l=0.5u
M_98 net_6480 net_6481 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6482 net_6483 net_6484 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6485 VSS nch_25od w=10u l=0.5u
M_101 net_6486 net_6483 net_6487 VSS nch_25od w=10u l=0.5u
M_102 net_6485 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6485 net_6480 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6485 net_6480 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6487 VSS nch w=10u l=0.09u
M_106 net_6482 net_6481 VSS VSS nch w=10u l=0.09u
M_107 net_6486 I net_6485 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6480 net_6481 net_6484 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6488 net_6489 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6490 net_6483 net_6491 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6492 VSS nch_25od w=10u l=0.5u
M_112 net_6493 net_6483 net_6494 VSS nch_25od w=10u l=0.5u
M_113 net_6492 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6492 net_6488 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6492 net_6488 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6494 VSS nch w=10u l=0.09u
M_117 net_6490 net_6489 VSS VSS nch w=10u l=0.09u
M_118 net_6493 OEN net_6492 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6488 net_6489 net_6491 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6495 net_6496 VDDPST pch_25od w=40u l=0.415u
M_121 net_6496 net_6497 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6498 net_6495 net_6496 VSS nch_25od w=20u l=0.5u
M_123 net_6498 net_6497 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6499 net_6500 VSS nch w=3u l=0.1u
M_125 net_6499 net_6500 VDD VDD pch w=4u l=0.1u
M_126 net_6500 net_6499 net_6499 VDD pch w=4u l=0.1u
M_127 net_6470 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6472 net_6501 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6470 net_6500 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6470 net_6472 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6472 net_6470 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6483 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6483 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6476 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6448 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6502 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6457 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6500 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6503 net_6480 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6503 net_6480 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6497 net_6488 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6497 net_6488 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6478 net_6485 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6478 net_6485 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6495 net_6503 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6495 net_6503 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6479 net_6492 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6479 net_6492 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6481 I VSS VSS nch w=3u l=0.09u
M_152 net_6481 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6489 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6489 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6501 net_6500 VSS VSS nch w=3u l=0.09u
M_156 net_6501 net_6500 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6504 C VSS nch w=20u l=0.09u
M_158 VSS net_6505 net_6504 VSS nch w=10u l=0.09u
M_159 VDD net_6504 C VDD pch w=30u l=0.09u
M_160 VDD net_6505 net_6504 VDD pch w=10u l=0.09u
M_161 VSS net_6474 net_6506 VSS nch_25od w=0.6u l=0.5u
M_162 net_6505 net_6506 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6507 net_6497 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6508 net_6502 net_6507 VSS nch_25od w=10u l=0.5u
M_165 net_6456 net_6502 net_6496 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6474 net_6505 VSS nch_25od w=5u l=0.5u
M_167 net_6476 net_6502 net_6471 VSS nch_25od w=30u l=0.5u
M_168 net_6509 net_6502 net_6508 VSS nch_25od w=10u l=0.5u
M_169 net_6471 net_6479 net_6509 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6474 net_6506 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6508 net_6502 net_6476 net_6455 pch_25od w=26u l=0.415u
M_172 net_6456 net_6508 net_6496 net_6455 pch_25od w=26u l=0.415u
M_173 VDD net_6474 net_6505 VDD pch_25od w=5u l=0.415u
M_174 net_6455 net_6508 VDDPST net_6455 pch_25od w=24u l=0.415u
M_175 net_6455 net_6502 net_6476 net_6455 pch_25od w=24u l=0.415u
M_176 net_6456 net_6502 net_6476 net_6455 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU16DGZ
.SUBCKT PRU16SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6510 net_6511 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6512 net_6513 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6514 net_6514 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6514 net_6514 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6514 net_6514 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6514 net_6514 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6515 net_6516 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6516 net_6517 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6517 net_6517 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6516 net_6516 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6511 net_6515 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6513 net_6510 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6518 net_6518 rppolywo w=0.4u l=1.3u m=1
X_14 net_6518 net_6518 rppolywo w=0.4u l=1.3u m=1
X_15 net_6518 net_6518 rppolywo w=0.4u l=1.3u m=1
X_16 net_6519 net_6519 rppolywo w=0.4u l=1.3u m=1
X_17 net_6519 net_6519 rppolywo w=0.4u l=1.3u m=1
X_18 net_6519 net_6519 rppolywo w=0.4u l=1.3u m=1
X_19 net_6520 net_6520 rppolywo w=0.4u l=1.3u m=1
X_20 net_6520 net_6520 rppolywo w=0.4u l=1.3u m=1
X_21 net_6520 net_6520 rppolywo w=0.4u l=1.3u m=1
X_22 net_6521 net_6521 rppolywo w=0.4u l=1.3u m=1
X_23 net_6521 net_6521 rppolywo w=0.4u l=1.3u m=1
X_24 net_6521 net_6521 rppolywo w=0.4u l=1.3u m=1
X_25 net_6521 net_6521 rppolywo w=0.4u l=1.3u m=1
X_26 net_6522 net_6519 rppolywo w=0.4u l=1.3u m=1
X_27 net_6519 net_6518 rppolywo w=0.4u l=1.3u m=1
X_28 net_6518 net_6520 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6523 net_6524 VSS nch_25od w=33u l=0.5u
M_30 net_6525 net_6515 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6523 net_6525 VSS nch_25od w=33u l=0.5u
M_32 net_6524 net_6513 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6523 net_6526 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6523 net_6527 VSS nch_25od w=33u l=0.5u
M_35 PAD net_6523 net_6528 VSS nch_25od w=33u l=0.5u
M_36 net_6528 net_6511 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_6523 net_6529 VSS nch_25od w=33u l=0.5u
M_38 net_6526 net_6516 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6527 net_6516 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6529 net_6510 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6530 net_6514 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6531 net_6514 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6532 net_6514 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6533 net_6514 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6523 net_6530 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6523 net_6531 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6523 net_6532 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6523 net_6533 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6523 net_6534 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6523 net_6535 VSS nch_25od w=33u l=0.5u
M_51 net_6534 net_6517 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6535 net_6517 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_54 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_55 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_56 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_57 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_58 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_59 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_60 PAD net_6518 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_61 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_62 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_63 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_64 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_65 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_66 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_67 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_68 PAD net_6519 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_69 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_70 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_71 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_72 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_73 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_74 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_75 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_76 PAD net_6521 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_77 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_78 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_79 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_80 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_81 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_82 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_83 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_84 PAD net_6520 VDDPST net_6521 pch_25od w=16.5u l=0.415u
M_85 VSS net_6536 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6521 net_6521 net_6521 net_6521 pch_25od w=0.5u l=0.9u
M_87 net_6537 net_6538 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_6539 net_6540 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_6539 net_6537 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6540 net_6537 net_6539 VSS nch_25od w=5u l=0.5u
M_91 net_6541 net_6540 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6540 net_6537 net_6541 VDDPST pch_25od w=5u l=0.415u
M_93 net_6541 net_6542 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6543 net_6544 net_6512 VDDPST pch_25od w=20u l=0.415u
M_95 net_6543 net_6545 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6512 net_6545 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6544 net_6512 VSS nch_25od w=15u l=0.5u
M_98 net_6546 net_6547 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6548 net_6549 net_6550 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6551 VSS nch_25od w=10u l=0.5u
M_101 net_6552 net_6549 net_6553 VSS nch_25od w=10u l=0.5u
M_102 net_6551 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6551 net_6546 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6551 net_6546 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6553 VSS nch w=10u l=0.09u
M_106 net_6548 net_6547 VSS VSS nch w=10u l=0.09u
M_107 net_6552 I net_6551 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6546 net_6547 net_6550 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6554 net_6555 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6556 net_6549 net_6557 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6558 VSS nch_25od w=10u l=0.5u
M_112 net_6559 net_6549 net_6560 VSS nch_25od w=10u l=0.5u
M_113 net_6558 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6558 net_6554 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6558 net_6554 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6560 VSS nch w=10u l=0.09u
M_117 net_6556 net_6555 VSS VSS nch w=10u l=0.09u
M_118 net_6559 OEN net_6558 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6554 net_6555 net_6557 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6561 net_6562 VDDPST pch_25od w=40u l=0.415u
M_121 net_6562 net_6563 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6564 net_6561 net_6562 VSS nch_25od w=20u l=0.5u
M_123 net_6564 net_6563 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6565 net_6566 VSS nch w=3u l=0.1u
M_125 net_6565 net_6566 VDD VDD pch w=4u l=0.1u
M_126 net_6566 net_6565 net_6565 VDD pch w=4u l=0.1u
M_127 net_6536 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6538 net_6567 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6536 net_6566 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6536 net_6538 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6538 net_6536 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6549 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6549 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6542 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6514 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6568 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6523 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6566 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6569 net_6546 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6569 net_6546 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6563 net_6554 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6563 net_6554 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6544 net_6551 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6544 net_6551 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6561 net_6569 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6561 net_6569 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6545 net_6558 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6545 net_6558 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6547 I VSS VSS nch w=3u l=0.09u
M_152 net_6547 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6555 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6555 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6567 net_6566 VSS VSS nch w=3u l=0.09u
M_156 net_6567 net_6566 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6570 C VSS nch w=20u l=0.09u
M_158 VSS net_6571 net_6570 VSS nch w=10u l=0.09u
M_159 VDD net_6570 C VDD pch w=30u l=0.09u
M_160 VDD net_6571 net_6570 VDD pch w=10u l=0.09u
M_161 VSS net_6540 net_6572 VSS nch_25od w=0.6u l=0.5u
M_162 net_6571 net_6572 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6573 net_6563 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6574 net_6568 net_6573 VSS nch_25od w=10u l=0.5u
M_165 net_6522 net_6568 net_6562 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6540 net_6571 VSS nch_25od w=5u l=0.5u
M_167 net_6542 net_6568 net_6537 VSS nch_25od w=30u l=0.5u
M_168 net_6575 net_6568 net_6574 VSS nch_25od w=10u l=0.5u
M_169 net_6537 net_6545 net_6575 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6540 net_6572 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6574 net_6568 net_6542 net_6521 pch_25od w=26u l=0.415u
M_172 net_6522 net_6574 net_6562 net_6521 pch_25od w=26u l=0.415u
M_173 VDD net_6540 net_6571 VDD pch_25od w=5u l=0.415u
M_174 net_6521 net_6574 VDDPST net_6521 pch_25od w=24u l=0.415u
M_175 net_6521 net_6568 net_6542 net_6521 pch_25od w=24u l=0.415u
M_176 net_6522 net_6568 net_6542 net_6521 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU16SDGZ
.SUBCKT PRU24DGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6576 net_6577 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6578 net_6579 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6580 net_6581 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6577 net_6577 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6582 net_6582 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6578 net_6578 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6582 net_6578 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6579 net_6579 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6579 net_6579 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6579 net_6579 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6577 net_6582 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6581 net_6576 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_14 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_15 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_16 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_17 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_18 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_19 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_20 net_6583 net_6583 rppolywo w=0.4u l=1.3u m=1
X_21 net_6584 net_6584 rppolywo w=0.4u l=1.3u m=1
X_22 net_6584 net_6584 rppolywo w=0.4u l=1.3u m=1
X_23 net_6585 net_6585 rppolywo w=0.4u l=1.3u m=1
X_24 net_6585 net_6585 rppolywo w=0.4u l=1.3u m=1
X_25 net_6585 net_6585 rppolywo w=0.4u l=1.3u m=1
X_26 net_6586 net_6583 rppolywo w=0.4u l=1.3u m=1
X_27 net_6583 net_6584 rppolywo w=0.4u l=1.3u m=1
X_28 net_6584 net_6585 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6587 net_6588 VSS nch_25od w=33u l=0.5u
M_30 net_6589 net_6582 VSS VSS nch_25od w=33u l=0.5u
M_31 net_6590 net_6582 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_6587 net_6589 VSS nch_25od w=33u l=0.5u
M_33 PAD net_6587 net_6590 VSS nch_25od w=33u l=0.5u
M_34 net_6591 net_6579 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6592 net_6579 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6593 net_6579 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6588 net_6581 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_6587 net_6591 VSS nch_25od w=33u l=0.5u
M_39 PAD net_6587 net_6592 VSS nch_25od w=33u l=0.5u
M_40 PAD net_6587 net_6593 VSS nch_25od w=33u l=0.5u
M_41 PAD net_6587 net_6594 VSS nch_25od w=33u l=0.5u
M_42 PAD net_6587 net_6595 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6587 net_6596 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6587 net_6597 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6587 net_6598 VSS nch_25od w=33u l=0.5u
M_46 net_6597 net_6577 VSS VSS nch_25od w=33u l=0.5u
M_47 net_6598 net_6577 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_6587 net_6599 VSS nch_25od w=33u l=0.5u
M_49 net_6594 net_6578 VSS VSS nch_25od w=33u l=0.5u
M_50 net_6595 net_6578 VSS VSS nch_25od w=33u l=0.5u
M_51 net_6596 net_6578 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6599 net_6576 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_54 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_55 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_56 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_57 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_58 PAD net_6584 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_59 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_60 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_61 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_62 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_63 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_64 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_65 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_66 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_67 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_68 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_69 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_70 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_71 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_72 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_73 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_74 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_75 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_76 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_77 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_78 PAD net_6583 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_79 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_80 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_81 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_82 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_83 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_84 PAD net_6585 VDDPST net_6600 pch_25od w=16.5u l=0.415u
M_85 VSS net_6601 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6600 net_6600 net_6600 net_6600 pch_25od w=0.5u l=0.9u
M_87 net_6602 net_6603 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6604 net_6602 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6605 net_6602 net_6604 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6605 net_6602 net_6606 VDDPST pch_25od w=5u l=0.415u
M_93 net_6606 net_6607 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6608 net_6609 net_6580 VDDPST pch_25od w=20u l=0.415u
M_95 net_6608 net_6610 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6580 net_6610 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6609 net_6580 VSS nch_25od w=15u l=0.5u
M_98 net_6611 net_6612 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6613 net_6614 net_6615 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6616 VSS nch_25od w=10u l=0.5u
M_101 net_6617 net_6614 net_6618 VSS nch_25od w=10u l=0.5u
M_102 net_6616 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6616 net_6611 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6616 net_6611 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6618 VSS nch w=10u l=0.09u
M_106 net_6613 net_6612 VSS VSS nch w=10u l=0.09u
M_107 net_6617 I net_6616 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6611 net_6612 net_6615 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6619 net_6620 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6621 net_6614 net_6622 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6623 VSS nch_25od w=10u l=0.5u
M_112 net_6624 net_6614 net_6625 VSS nch_25od w=10u l=0.5u
M_113 net_6623 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6623 net_6619 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6623 net_6619 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6625 VSS nch w=10u l=0.09u
M_117 net_6621 net_6620 VSS VSS nch w=10u l=0.09u
M_118 net_6624 OEN net_6623 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6619 net_6620 net_6622 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6626 net_6627 VDDPST pch_25od w=40u l=0.415u
M_121 net_6627 net_6628 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6629 net_6626 net_6627 VSS nch_25od w=20u l=0.5u
M_123 net_6629 net_6628 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6630 net_6631 VSS nch w=3u l=0.1u
M_125 net_6630 net_6631 VDD VDD pch w=4u l=0.1u
M_126 net_6631 net_6630 net_6630 VDD pch w=4u l=0.1u
M_127 net_6601 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6603 net_6632 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6601 net_6631 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6601 net_6603 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6603 net_6601 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6614 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6614 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6607 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6633 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6634 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6587 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6631 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6635 net_6611 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6635 net_6611 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6628 net_6619 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6628 net_6619 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6609 net_6616 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6609 net_6616 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6626 net_6635 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6626 net_6635 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6610 net_6623 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6610 net_6623 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6612 I VSS VSS nch w=3u l=0.09u
M_152 net_6612 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6620 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6620 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6632 net_6631 VSS VSS nch w=3u l=0.09u
M_156 net_6632 net_6631 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6636 C VSS nch w=20u l=0.09u
M_158 VSS net_6637 net_6636 VSS nch w=10u l=0.09u
M_159 VDD net_6636 C VDD pch w=30u l=0.09u
M_160 VDD net_6637 net_6636 VDD pch w=10u l=0.09u
M_161 VSS net_6605 net_6638 VSS nch_25od w=0.6u l=0.5u
M_162 net_6637 net_6638 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6639 net_6628 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6640 net_6634 net_6639 VSS nch_25od w=10u l=0.5u
M_165 net_6586 net_6634 net_6627 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6605 net_6637 VSS nch_25od w=5u l=0.5u
M_167 net_6607 net_6634 net_6602 VSS nch_25od w=30u l=0.5u
M_168 net_6641 net_6634 net_6640 VSS nch_25od w=10u l=0.5u
M_169 net_6602 net_6610 net_6641 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6605 net_6638 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6640 net_6634 net_6607 net_6600 pch_25od w=26u l=0.415u
M_172 net_6586 net_6640 net_6627 net_6600 pch_25od w=26u l=0.415u
M_173 VDD net_6605 net_6637 VDD pch_25od w=5u l=0.415u
M_174 net_6600 net_6640 VDDPST net_6600 pch_25od w=24u l=0.415u
M_175 net_6600 net_6634 net_6607 net_6600 pch_25od w=24u l=0.415u
M_176 net_6586 net_6634 net_6607 net_6600 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU24DGZ
.SUBCKT PRU24SDGZ C PAD I OEN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6642 net_6643 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6644 net_6645 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6646 net_6647 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6643 net_6643 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6648 net_6648 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6644 net_6644 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6648 net_6644 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6645 net_6645 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6645 net_6645 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6645 net_6645 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6643 net_6648 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6647 net_6642 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_14 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_15 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_16 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_17 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_18 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_19 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_20 net_6649 net_6649 rppolywo w=0.4u l=1.3u m=1
X_21 net_6650 net_6650 rppolywo w=0.4u l=1.3u m=1
X_22 net_6650 net_6650 rppolywo w=0.4u l=1.3u m=1
X_23 net_6651 net_6651 rppolywo w=0.4u l=1.3u m=1
X_24 net_6651 net_6651 rppolywo w=0.4u l=1.3u m=1
X_25 net_6651 net_6651 rppolywo w=0.4u l=1.3u m=1
X_26 net_6652 net_6649 rppolywo w=0.4u l=1.3u m=1
X_27 net_6649 net_6650 rppolywo w=0.4u l=1.3u m=1
X_28 net_6650 net_6651 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6653 net_6654 VSS nch_25od w=33u l=0.5u
M_30 net_6655 net_6648 VSS VSS nch_25od w=33u l=0.5u
M_31 net_6656 net_6648 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_6653 net_6655 VSS nch_25od w=33u l=0.5u
M_33 PAD net_6653 net_6656 VSS nch_25od w=33u l=0.5u
M_34 net_6657 net_6645 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6658 net_6645 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6659 net_6645 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6654 net_6647 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_6653 net_6657 VSS nch_25od w=33u l=0.5u
M_39 PAD net_6653 net_6658 VSS nch_25od w=33u l=0.5u
M_40 PAD net_6653 net_6659 VSS nch_25od w=33u l=0.5u
M_41 PAD net_6653 net_6660 VSS nch_25od w=33u l=0.5u
M_42 PAD net_6653 net_6661 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6653 net_6662 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6653 net_6663 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6653 net_6664 VSS nch_25od w=33u l=0.5u
M_46 net_6663 net_6643 VSS VSS nch_25od w=33u l=0.5u
M_47 net_6664 net_6643 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_6653 net_6665 VSS nch_25od w=33u l=0.5u
M_49 net_6660 net_6644 VSS VSS nch_25od w=33u l=0.5u
M_50 net_6661 net_6644 VSS VSS nch_25od w=33u l=0.5u
M_51 net_6662 net_6644 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6665 net_6642 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_54 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_55 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_56 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_57 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_58 PAD net_6650 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_59 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_60 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_61 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_62 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_63 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_64 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_65 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_66 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_67 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_68 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_69 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_70 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_71 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_72 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_73 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_74 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_75 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_76 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_77 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_78 PAD net_6649 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_79 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_80 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_81 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_82 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_83 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_84 PAD net_6651 VDDPST net_6666 pch_25od w=16.5u l=0.415u
M_85 VSS net_6667 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6666 net_6666 net_6666 net_6666 pch_25od w=0.5u l=0.9u
M_87 net_6668 net_6669 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 net_6670 net_6671 VDDPST VSS nch_25od w=2.1u l=0.5u
M_89 net_6670 net_6668 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6671 net_6668 net_6670 VSS nch_25od w=5u l=0.5u
M_91 net_6672 net_6671 VSS VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6671 net_6668 net_6672 VDDPST pch_25od w=5u l=0.415u
M_93 net_6672 net_6673 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6674 net_6675 net_6646 VDDPST pch_25od w=20u l=0.415u
M_95 net_6674 net_6676 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6646 net_6676 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6675 net_6646 VSS nch_25od w=15u l=0.5u
M_98 net_6677 net_6678 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6679 net_6680 net_6681 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6682 VSS nch_25od w=10u l=0.5u
M_101 net_6683 net_6680 net_6684 VSS nch_25od w=10u l=0.5u
M_102 net_6682 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6682 net_6677 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6682 net_6677 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6684 VSS nch w=10u l=0.09u
M_106 net_6679 net_6678 VSS VSS nch w=10u l=0.09u
M_107 net_6683 I net_6682 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6677 net_6678 net_6681 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6685 net_6686 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6687 net_6680 net_6688 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6689 VSS nch_25od w=10u l=0.5u
M_112 net_6690 net_6680 net_6691 VSS nch_25od w=10u l=0.5u
M_113 net_6689 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6689 net_6685 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6689 net_6685 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6691 VSS nch w=10u l=0.09u
M_117 net_6687 net_6686 VSS VSS nch w=10u l=0.09u
M_118 net_6690 OEN net_6689 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6685 net_6686 net_6688 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6692 net_6693 VDDPST pch_25od w=40u l=0.415u
M_121 net_6693 net_6694 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6695 net_6692 net_6693 VSS nch_25od w=20u l=0.5u
M_123 net_6695 net_6694 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6696 net_6697 VSS nch w=3u l=0.1u
M_125 net_6696 net_6697 VDD VDD pch w=4u l=0.1u
M_126 net_6697 net_6696 net_6696 VDD pch w=4u l=0.1u
M_127 net_6667 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6669 net_6698 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6667 net_6697 VSS VSS nch_25od w=20u l=0.5u
M_130 net_6667 net_6669 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6669 net_6667 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6680 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6680 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6673 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6699 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6700 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6653 rppolywo w=3.5u l=0.8u m=1
D_138 VSS net_6697 ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6701 net_6677 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6701 net_6677 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6694 net_6685 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6694 net_6685 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6675 net_6682 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6675 net_6682 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6692 net_6701 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6692 net_6701 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6676 net_6689 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6676 net_6689 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6678 I VSS VSS nch w=3u l=0.09u
M_152 net_6678 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6686 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6686 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6698 net_6697 VSS VSS nch w=3u l=0.09u
M_156 net_6698 net_6697 VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6702 C VSS nch w=20u l=0.09u
M_158 VSS net_6703 net_6702 VSS nch w=10u l=0.09u
M_159 VDD net_6702 C VDD pch w=30u l=0.09u
M_160 VDD net_6703 net_6702 VDD pch w=10u l=0.09u
M_161 VSS net_6671 net_6704 VSS nch_25od w=0.6u l=0.5u
M_162 net_6703 net_6704 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6705 net_6694 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6706 net_6700 net_6705 VSS nch_25od w=10u l=0.5u
M_165 net_6652 net_6700 net_6693 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6671 net_6703 VSS nch_25od w=5u l=0.5u
M_167 net_6673 net_6700 net_6668 VSS nch_25od w=30u l=0.5u
M_168 net_6707 net_6700 net_6706 VSS nch_25od w=10u l=0.5u
M_169 net_6668 net_6676 net_6707 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6671 net_6704 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6706 net_6700 net_6673 net_6666 pch_25od w=26u l=0.415u
M_172 net_6652 net_6706 net_6693 net_6666 pch_25od w=26u l=0.415u
M_173 VDD net_6671 net_6703 VDD pch_25od w=5u l=0.415u
M_174 net_6666 net_6706 VDDPST net_6666 pch_25od w=24u l=0.415u
M_175 net_6666 net_6700 net_6673 net_6666 pch_25od w=24u l=0.415u
M_176 net_6652 net_6700 net_6673 net_6666 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRU24SDGZ
.SUBCKT PRUW08DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6708 net_6709 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6710 net_6710 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6709 net_6711 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6712 net_6708 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6713 net_6712 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6714 net_6714 rppolywo w=0.4u l=1.3u m=1
X_14 net_6715 net_6715 rppolywo w=0.4u l=1.3u m=1
X_15 net_6716 net_6716 rppolywo w=0.4u l=1.3u m=1
X_16 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_17 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_18 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_19 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_20 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_21 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_22 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_23 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_24 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_25 net_6717 net_6717 rppolywo w=0.4u l=1.3u m=1
X_26 net_6718 net_6714 rppolywo w=0.4u l=1.3u m=1
X_27 net_6714 net_6715 rppolywo w=0.4u l=1.3u m=1
X_28 net_6715 net_6716 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6719 net_6720 VSS nch_25od w=33u l=0.5u
M_30 PAD net_6719 net_6721 VSS nch_25od w=33u l=0.5u
M_31 net_6721 net_6712 VSS VSS nch_25od w=33u l=0.5u
M_32 net_6720 net_6709 VSS VSS nch_25od w=33u l=0.5u
M_33 net_6722 net_6708 VSS VSS nch_25od w=33u l=0.5u
M_34 net_6723 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6724 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6725 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6726 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6727 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6728 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6729 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6730 net_6710 VSS VSS nch_25od w=33u l=0.5u
M_42 PAD net_6719 net_6723 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6719 net_6724 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6719 net_6725 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6719 net_6726 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6719 net_6727 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6719 net_6728 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6719 net_6729 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6719 net_6730 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6719 net_6722 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6719 net_6731 VSS nch_25od w=33u l=0.5u
M_52 net_6731 net_6711 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6714 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_54 PAD net_6714 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_55 PAD net_6714 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_56 PAD net_6714 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_57 PAD net_6715 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_58 PAD net_6715 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_59 PAD net_6715 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_60 PAD net_6715 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_61 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_62 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_63 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_64 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_65 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_66 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_67 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_68 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_69 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_70 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_71 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_72 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_73 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_74 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_75 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_76 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_77 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_78 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_79 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_80 PAD net_6717 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_81 PAD net_6716 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_82 PAD net_6716 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_83 PAD net_6716 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_84 PAD net_6716 VDDPST net_6717 pch_25od w=16.5u l=0.415u
M_85 VSS net_6732 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6717 net_6717 net_6717 net_6717 pch_25od w=0.5u l=0.9u
M_87 net_6733 net_6734 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6735 net_6733 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6736 net_6733 net_6735 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6736 net_6733 net_6737 VDDPST pch_25od w=5u l=0.415u
M_93 net_6737 net_6738 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6739 net_6740 net_6713 VDDPST pch_25od w=20u l=0.415u
M_95 net_6739 net_6741 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6713 net_6741 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6740 net_6713 VSS nch_25od w=15u l=0.5u
M_98 net_6742 net_6743 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6744 net_6745 net_6746 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6747 VSS nch_25od w=10u l=0.5u
M_101 net_6748 net_6745 net_6749 VSS nch_25od w=10u l=0.5u
M_102 net_6747 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6747 net_6742 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6747 net_6742 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6749 VSS nch w=10u l=0.09u
M_106 net_6744 net_6743 VSS VSS nch w=10u l=0.09u
M_107 net_6748 I net_6747 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6742 net_6743 net_6746 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6750 net_6751 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6752 net_6745 net_6753 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6754 VSS nch_25od w=10u l=0.5u
M_112 net_6755 net_6745 net_6756 VSS nch_25od w=10u l=0.5u
M_113 net_6754 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6754 net_6750 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6754 net_6750 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6756 VSS nch w=10u l=0.09u
M_117 net_6752 net_6751 VSS VSS nch w=10u l=0.09u
M_118 net_6755 OEN net_6754 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6750 net_6751 net_6753 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6757 net_6758 VDDPST pch_25od w=40u l=0.415u
M_121 net_6758 net_6759 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6760 net_6757 net_6758 VSS nch_25od w=20u l=0.5u
M_123 net_6760 net_6759 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6761 net_6762 VSS nch w=3u l=0.1u
M_125 net_6761 net_6762 VDD VDD pch w=4u l=0.1u
M_126 net_6762 net_6761 net_6761 VDD pch w=4u l=0.1u
M_127 net_6732 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6734 net_6763 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6732 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_6732 net_6734 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6734 net_6732 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6745 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6745 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6738 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6710 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6764 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6719 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6765 net_6742 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6765 net_6742 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6759 net_6750 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6759 net_6750 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6740 net_6747 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6740 net_6747 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6757 net_6765 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6757 net_6765 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6741 net_6754 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6741 net_6754 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6743 I VSS VSS nch w=3u l=0.09u
M_152 net_6743 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6751 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6751 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6763 REN VSS VSS nch w=3u l=0.09u
M_156 net_6763 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6766 C VSS nch w=20u l=0.09u
M_158 VSS net_6767 net_6766 VSS nch w=10u l=0.09u
M_159 VDD net_6766 C VDD pch w=30u l=0.09u
M_160 VDD net_6767 net_6766 VDD pch w=10u l=0.09u
M_161 VSS net_6736 net_6768 VSS nch_25od w=0.6u l=0.5u
M_162 net_6767 net_6768 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6769 net_6759 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6770 net_6764 net_6769 VSS nch_25od w=10u l=0.5u
M_165 net_6718 net_6764 net_6758 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6736 net_6767 VSS nch_25od w=5u l=0.5u
M_167 net_6738 net_6764 net_6733 VSS nch_25od w=30u l=0.5u
M_168 net_6771 net_6764 net_6770 VSS nch_25od w=10u l=0.5u
M_169 net_6733 net_6741 net_6771 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6736 net_6768 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6770 net_6764 net_6738 net_6717 pch_25od w=26u l=0.415u
M_172 net_6718 net_6770 net_6758 net_6717 pch_25od w=26u l=0.415u
M_173 VDD net_6736 net_6767 VDD pch_25od w=5u l=0.415u
M_174 net_6717 net_6770 VDDPST net_6717 pch_25od w=24u l=0.415u
M_175 net_6717 net_6764 net_6738 net_6717 pch_25od w=24u l=0.415u
M_176 net_6718 net_6764 net_6738 net_6717 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRUW08DGZ
.SUBCKT PRUW12DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6772 net_6773 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6774 net_6775 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6776 net_6777 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6777 net_6778 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6779 net_6779 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6773 net_6776 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6775 net_6772 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6780 net_6780 rppolywo w=0.4u l=1.3u m=1
X_14 net_6780 net_6780 rppolywo w=0.4u l=1.3u m=1
X_15 net_6781 net_6781 rppolywo w=0.4u l=1.3u m=1
X_16 net_6781 net_6781 rppolywo w=0.4u l=1.3u m=1
X_17 net_6782 net_6782 rppolywo w=0.4u l=1.3u m=1
X_18 net_6782 net_6782 rppolywo w=0.4u l=1.3u m=1
X_19 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_20 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_21 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_22 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_23 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_24 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_25 net_6783 net_6783 rppolywo w=0.4u l=1.3u m=1
X_26 net_6784 net_6780 rppolywo w=0.4u l=1.3u m=1
X_27 net_6780 net_6781 rppolywo w=0.4u l=1.3u m=1
X_28 net_6781 net_6782 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6785 net_6786 VSS nch_25od w=33u l=0.5u
M_30 net_6787 net_6776 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6785 net_6787 VSS nch_25od w=33u l=0.5u
M_32 net_6786 net_6775 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6785 net_6788 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6785 net_6789 VSS nch_25od w=33u l=0.5u
M_35 net_6789 net_6773 VSS VSS nch_25od w=33u l=0.5u
M_36 PAD net_6785 net_6790 VSS nch_25od w=33u l=0.5u
M_37 net_6788 net_6777 VSS VSS nch_25od w=33u l=0.5u
M_38 net_6790 net_6772 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6791 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6792 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6793 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6794 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6795 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6796 net_6779 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6785 net_6791 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6785 net_6792 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6785 net_6793 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6785 net_6794 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6785 net_6795 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6785 net_6796 VSS nch_25od w=33u l=0.5u
M_51 PAD net_6785 net_6797 VSS nch_25od w=33u l=0.5u
M_52 net_6797 net_6778 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_54 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_55 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_56 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_57 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_58 PAD net_6780 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_59 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_60 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_61 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_62 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_63 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_64 PAD net_6781 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_65 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_66 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_67 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_68 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_69 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_70 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_71 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_72 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_73 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_74 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_75 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_76 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_77 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_78 PAD net_6783 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_79 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_80 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_81 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_82 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_83 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_84 PAD net_6782 VDDPST net_6783 pch_25od w=16.5u l=0.415u
M_85 VSS net_6798 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6783 net_6783 net_6783 net_6783 pch_25od w=0.5u l=0.9u
M_87 net_6799 net_6800 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6801 net_6799 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6802 net_6799 net_6801 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6802 net_6799 net_6803 VDDPST pch_25od w=5u l=0.415u
M_93 net_6803 net_6804 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6805 net_6806 net_6774 VDDPST pch_25od w=20u l=0.415u
M_95 net_6805 net_6807 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6774 net_6807 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6806 net_6774 VSS nch_25od w=15u l=0.5u
M_98 net_6808 net_6809 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6810 net_6811 net_6812 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6813 VSS nch_25od w=10u l=0.5u
M_101 net_6814 net_6811 net_6815 VSS nch_25od w=10u l=0.5u
M_102 net_6813 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6813 net_6808 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6813 net_6808 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6815 VSS nch w=10u l=0.09u
M_106 net_6810 net_6809 VSS VSS nch w=10u l=0.09u
M_107 net_6814 I net_6813 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6808 net_6809 net_6812 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6816 net_6817 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6818 net_6811 net_6819 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6820 VSS nch_25od w=10u l=0.5u
M_112 net_6821 net_6811 net_6822 VSS nch_25od w=10u l=0.5u
M_113 net_6820 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6820 net_6816 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6820 net_6816 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6822 VSS nch w=10u l=0.09u
M_117 net_6818 net_6817 VSS VSS nch w=10u l=0.09u
M_118 net_6821 OEN net_6820 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6816 net_6817 net_6819 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6823 net_6824 VDDPST pch_25od w=40u l=0.415u
M_121 net_6824 net_6825 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6826 net_6823 net_6824 VSS nch_25od w=20u l=0.5u
M_123 net_6826 net_6825 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6827 net_6828 VSS nch w=3u l=0.1u
M_125 net_6827 net_6828 VDD VDD pch w=4u l=0.1u
M_126 net_6828 net_6827 net_6827 VDD pch w=4u l=0.1u
M_127 net_6798 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6800 net_6829 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6798 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_6798 net_6800 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6800 net_6798 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6811 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6811 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6804 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6779 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6830 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6785 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6831 net_6808 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6831 net_6808 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6825 net_6816 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6825 net_6816 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6806 net_6813 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6806 net_6813 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6823 net_6831 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6823 net_6831 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6807 net_6820 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6807 net_6820 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6809 I VSS VSS nch w=3u l=0.09u
M_152 net_6809 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6817 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6817 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6829 REN VSS VSS nch w=3u l=0.09u
M_156 net_6829 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6832 C VSS nch w=20u l=0.09u
M_158 VSS net_6833 net_6832 VSS nch w=10u l=0.09u
M_159 VDD net_6832 C VDD pch w=30u l=0.09u
M_160 VDD net_6833 net_6832 VDD pch w=10u l=0.09u
M_161 VSS net_6802 net_6834 VSS nch_25od w=0.6u l=0.5u
M_162 net_6833 net_6834 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6835 net_6825 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6836 net_6830 net_6835 VSS nch_25od w=10u l=0.5u
M_165 net_6784 net_6830 net_6824 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6802 net_6833 VSS nch_25od w=5u l=0.5u
M_167 net_6804 net_6830 net_6799 VSS nch_25od w=30u l=0.5u
M_168 net_6837 net_6830 net_6836 VSS nch_25od w=10u l=0.5u
M_169 net_6799 net_6807 net_6837 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6802 net_6834 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6836 net_6830 net_6804 net_6783 pch_25od w=26u l=0.415u
M_172 net_6784 net_6836 net_6824 net_6783 pch_25od w=26u l=0.415u
M_173 VDD net_6802 net_6833 VDD pch_25od w=5u l=0.415u
M_174 net_6783 net_6836 VDDPST net_6783 pch_25od w=24u l=0.415u
M_175 net_6783 net_6830 net_6804 net_6783 pch_25od w=24u l=0.415u
M_176 net_6784 net_6830 net_6804 net_6783 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRUW12DGZ
.SUBCKT PRUW16DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6838 net_6839 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6840 net_6841 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6842 net_6842 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6842 net_6842 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6842 net_6842 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6842 net_6842 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6843 net_6844 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6844 net_6845 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6845 net_6845 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6844 net_6844 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6839 net_6843 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6841 net_6838 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6846 net_6846 rppolywo w=0.4u l=1.3u m=1
X_14 net_6846 net_6846 rppolywo w=0.4u l=1.3u m=1
X_15 net_6846 net_6846 rppolywo w=0.4u l=1.3u m=1
X_16 net_6847 net_6847 rppolywo w=0.4u l=1.3u m=1
X_17 net_6847 net_6847 rppolywo w=0.4u l=1.3u m=1
X_18 net_6847 net_6847 rppolywo w=0.4u l=1.3u m=1
X_19 net_6848 net_6848 rppolywo w=0.4u l=1.3u m=1
X_20 net_6848 net_6848 rppolywo w=0.4u l=1.3u m=1
X_21 net_6848 net_6848 rppolywo w=0.4u l=1.3u m=1
X_22 net_6849 net_6849 rppolywo w=0.4u l=1.3u m=1
X_23 net_6849 net_6849 rppolywo w=0.4u l=1.3u m=1
X_24 net_6849 net_6849 rppolywo w=0.4u l=1.3u m=1
X_25 net_6849 net_6849 rppolywo w=0.4u l=1.3u m=1
X_26 net_6850 net_6847 rppolywo w=0.4u l=1.3u m=1
X_27 net_6847 net_6846 rppolywo w=0.4u l=1.3u m=1
X_28 net_6846 net_6848 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6851 net_6852 VSS nch_25od w=33u l=0.5u
M_30 net_6853 net_6843 VSS VSS nch_25od w=33u l=0.5u
M_31 PAD net_6851 net_6853 VSS nch_25od w=33u l=0.5u
M_32 net_6852 net_6841 VSS VSS nch_25od w=33u l=0.5u
M_33 PAD net_6851 net_6854 VSS nch_25od w=33u l=0.5u
M_34 PAD net_6851 net_6855 VSS nch_25od w=33u l=0.5u
M_35 PAD net_6851 net_6856 VSS nch_25od w=33u l=0.5u
M_36 net_6856 net_6839 VSS VSS nch_25od w=33u l=0.5u
M_37 PAD net_6851 net_6857 VSS nch_25od w=33u l=0.5u
M_38 net_6854 net_6844 VSS VSS nch_25od w=33u l=0.5u
M_39 net_6855 net_6844 VSS VSS nch_25od w=33u l=0.5u
M_40 net_6857 net_6838 VSS VSS nch_25od w=33u l=0.5u
M_41 net_6858 net_6842 VSS VSS nch_25od w=33u l=0.5u
M_42 net_6859 net_6842 VSS VSS nch_25od w=33u l=0.5u
M_43 net_6860 net_6842 VSS VSS nch_25od w=33u l=0.5u
M_44 net_6861 net_6842 VSS VSS nch_25od w=33u l=0.5u
M_45 PAD net_6851 net_6858 VSS nch_25od w=33u l=0.5u
M_46 PAD net_6851 net_6859 VSS nch_25od w=33u l=0.5u
M_47 PAD net_6851 net_6860 VSS nch_25od w=33u l=0.5u
M_48 PAD net_6851 net_6861 VSS nch_25od w=33u l=0.5u
M_49 PAD net_6851 net_6862 VSS nch_25od w=33u l=0.5u
M_50 PAD net_6851 net_6863 VSS nch_25od w=33u l=0.5u
M_51 net_6862 net_6845 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6863 net_6845 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_54 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_55 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_56 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_57 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_58 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_59 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_60 PAD net_6846 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_61 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_62 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_63 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_64 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_65 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_66 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_67 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_68 PAD net_6847 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_69 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_70 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_71 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_72 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_73 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_74 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_75 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_76 PAD net_6849 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_77 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_78 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_79 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_80 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_81 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_82 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_83 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_84 PAD net_6848 VDDPST net_6849 pch_25od w=16.5u l=0.415u
M_85 VSS net_6864 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6849 net_6849 net_6849 net_6849 pch_25od w=0.5u l=0.9u
M_87 net_6865 net_6866 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6867 net_6865 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6868 net_6865 net_6867 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6868 net_6865 net_6869 VDDPST pch_25od w=5u l=0.415u
M_93 net_6869 net_6870 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6871 net_6872 net_6840 VDDPST pch_25od w=20u l=0.415u
M_95 net_6871 net_6873 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6840 net_6873 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6872 net_6840 VSS nch_25od w=15u l=0.5u
M_98 net_6874 net_6875 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6876 net_6877 net_6878 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6879 VSS nch_25od w=10u l=0.5u
M_101 net_6880 net_6877 net_6881 VSS nch_25od w=10u l=0.5u
M_102 net_6879 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6879 net_6874 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6879 net_6874 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6881 VSS nch w=10u l=0.09u
M_106 net_6876 net_6875 VSS VSS nch w=10u l=0.09u
M_107 net_6880 I net_6879 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6874 net_6875 net_6878 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6882 net_6883 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6884 net_6877 net_6885 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6886 VSS nch_25od w=10u l=0.5u
M_112 net_6887 net_6877 net_6888 VSS nch_25od w=10u l=0.5u
M_113 net_6886 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6886 net_6882 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6886 net_6882 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6888 VSS nch w=10u l=0.09u
M_117 net_6884 net_6883 VSS VSS nch w=10u l=0.09u
M_118 net_6887 OEN net_6886 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6882 net_6883 net_6885 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6889 net_6890 VDDPST pch_25od w=40u l=0.415u
M_121 net_6890 net_6891 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6892 net_6889 net_6890 VSS nch_25od w=20u l=0.5u
M_123 net_6892 net_6891 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6893 net_6894 VSS nch w=3u l=0.1u
M_125 net_6893 net_6894 VDD VDD pch w=4u l=0.1u
M_126 net_6894 net_6893 net_6893 VDD pch w=4u l=0.1u
M_127 net_6864 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6866 net_6895 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6864 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_6864 net_6866 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6866 net_6864 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6877 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6877 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6870 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6842 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6896 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6851 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6897 net_6874 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6897 net_6874 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6891 net_6882 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6891 net_6882 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6872 net_6879 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6872 net_6879 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6889 net_6897 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6889 net_6897 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6873 net_6886 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6873 net_6886 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6875 I VSS VSS nch w=3u l=0.09u
M_152 net_6875 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6883 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6883 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6895 REN VSS VSS nch w=3u l=0.09u
M_156 net_6895 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6898 C VSS nch w=20u l=0.09u
M_158 VSS net_6899 net_6898 VSS nch w=10u l=0.09u
M_159 VDD net_6898 C VDD pch w=30u l=0.09u
M_160 VDD net_6899 net_6898 VDD pch w=10u l=0.09u
M_161 VSS net_6868 net_6900 VSS nch_25od w=0.6u l=0.5u
M_162 net_6899 net_6900 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6901 net_6891 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6902 net_6896 net_6901 VSS nch_25od w=10u l=0.5u
M_165 net_6850 net_6896 net_6890 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6868 net_6899 VSS nch_25od w=5u l=0.5u
M_167 net_6870 net_6896 net_6865 VSS nch_25od w=30u l=0.5u
M_168 net_6903 net_6896 net_6902 VSS nch_25od w=10u l=0.5u
M_169 net_6865 net_6873 net_6903 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6868 net_6900 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6902 net_6896 net_6870 net_6849 pch_25od w=26u l=0.415u
M_172 net_6850 net_6902 net_6890 net_6849 pch_25od w=26u l=0.415u
M_173 VDD net_6868 net_6899 VDD pch_25od w=5u l=0.415u
M_174 net_6849 net_6902 VDDPST net_6849 pch_25od w=24u l=0.415u
M_175 net_6849 net_6896 net_6870 net_6849 pch_25od w=24u l=0.415u
M_176 net_6850 net_6896 net_6870 net_6849 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRUW16DGZ
.SUBCKT PRUW24DGZ C PAD I OEN REN
D_0 VSS PAD ndio_esd area=562.656p
X_1 net_6904 net_6905 rnpolywo w=0.4u l=2.93u m=1
X_2 net_6906 net_6907 rnpolywo w=0.4u l=2.93u m=1
X_3 net_6908 net_6909 rnpolywo w=0.4u l=2.93u m=1
X_4 net_6905 net_6905 rnpolywo w=0.4u l=2.93u m=1
X_5 net_6910 net_6910 rnpolywo w=0.4u l=2.93u m=1
X_6 net_6906 net_6906 rnpolywo w=0.4u l=2.93u m=1
X_7 net_6910 net_6906 rnpolywo w=0.4u l=2.93u m=1
X_8 net_6907 net_6907 rnpolywo w=0.4u l=2.93u m=1
X_9 net_6907 net_6907 rnpolywo w=0.4u l=2.93u m=1
X_10 net_6907 net_6907 rnpolywo w=0.4u l=2.93u m=1
X_11 net_6905 net_6910 rnpolywo w=0.4u l=2.93u m=1
X_12 net_6909 net_6904 rnpolywo w=0.4u l=2.93u m=1
X_13 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_14 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_15 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_16 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_17 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_18 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_19 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_20 net_6911 net_6911 rppolywo w=0.4u l=1.3u m=1
X_21 net_6912 net_6912 rppolywo w=0.4u l=1.3u m=1
X_22 net_6912 net_6912 rppolywo w=0.4u l=1.3u m=1
X_23 net_6913 net_6913 rppolywo w=0.4u l=1.3u m=1
X_24 net_6913 net_6913 rppolywo w=0.4u l=1.3u m=1
X_25 net_6913 net_6913 rppolywo w=0.4u l=1.3u m=1
X_26 net_6914 net_6911 rppolywo w=0.4u l=1.3u m=1
X_27 net_6911 net_6912 rppolywo w=0.4u l=1.3u m=1
X_28 net_6912 net_6913 rppolywo w=0.4u l=1.3u m=1
M_29 PAD net_6915 net_6916 VSS nch_25od w=33u l=0.5u
M_30 net_6917 net_6910 VSS VSS nch_25od w=33u l=0.5u
M_31 net_6918 net_6910 VSS VSS nch_25od w=33u l=0.5u
M_32 PAD net_6915 net_6917 VSS nch_25od w=33u l=0.5u
M_33 PAD net_6915 net_6918 VSS nch_25od w=33u l=0.5u
M_34 net_6919 net_6907 VSS VSS nch_25od w=33u l=0.5u
M_35 net_6920 net_6907 VSS VSS nch_25od w=33u l=0.5u
M_36 net_6921 net_6907 VSS VSS nch_25od w=33u l=0.5u
M_37 net_6916 net_6909 VSS VSS nch_25od w=33u l=0.5u
M_38 PAD net_6915 net_6919 VSS nch_25od w=33u l=0.5u
M_39 PAD net_6915 net_6920 VSS nch_25od w=33u l=0.5u
M_40 PAD net_6915 net_6921 VSS nch_25od w=33u l=0.5u
M_41 PAD net_6915 net_6922 VSS nch_25od w=33u l=0.5u
M_42 PAD net_6915 net_6923 VSS nch_25od w=33u l=0.5u
M_43 PAD net_6915 net_6924 VSS nch_25od w=33u l=0.5u
M_44 PAD net_6915 net_6925 VSS nch_25od w=33u l=0.5u
M_45 PAD net_6915 net_6926 VSS nch_25od w=33u l=0.5u
M_46 net_6925 net_6905 VSS VSS nch_25od w=33u l=0.5u
M_47 net_6926 net_6905 VSS VSS nch_25od w=33u l=0.5u
M_48 PAD net_6915 net_6927 VSS nch_25od w=33u l=0.5u
M_49 net_6922 net_6906 VSS VSS nch_25od w=33u l=0.5u
M_50 net_6923 net_6906 VSS VSS nch_25od w=33u l=0.5u
M_51 net_6924 net_6906 VSS VSS nch_25od w=33u l=0.5u
M_52 net_6927 net_6904 VSS VSS nch_25od w=33u l=0.5u
M_53 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_54 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_55 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_56 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_57 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_58 PAD net_6912 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_59 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_60 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_61 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_62 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_63 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_64 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_65 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_66 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_67 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_68 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_69 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_70 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_71 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_72 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_73 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_74 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_75 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_76 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_77 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_78 PAD net_6911 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_79 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_80 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_81 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_82 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_83 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_84 PAD net_6913 VDDPST net_6928 pch_25od w=16.5u l=0.415u
M_85 VSS net_6929 VSS VSS nch_25od w=0.5u l=3u
M_86 net_6928 net_6928 net_6928 net_6928 pch_25od w=0.5u l=0.9u
M_87 net_6930 net_6931 VDDPST VDDPST pch_25od w=0.5u l=0.9u
M_88 VSS VSS VSS VSS nch_25od w=2.1u l=0.5u
M_89 net_6932 net_6930 VSS VSS nch_25od w=5u l=0.5u
M_90 net_6933 net_6930 net_6932 VSS nch_25od w=5u l=0.5u
M_91 VDDPST VDDPST VDDPST VDDPST pch_25od w=2.5u l=0.415u
M_92 net_6933 net_6930 net_6934 VDDPST pch_25od w=5u l=0.415u
M_93 net_6934 net_6935 VDDPST VDDPST pch_25od w=5u l=0.415u
M_94 net_6936 net_6937 net_6908 VDDPST pch_25od w=20u l=0.415u
M_95 net_6936 net_6938 VDDPST VDDPST pch_25od w=20u l=0.415u
M_96 net_6908 net_6938 VSS VSS nch_25od w=15u l=0.5u
M_97 VSS net_6937 net_6908 VSS nch_25od w=15u l=0.5u
M_98 net_6939 net_6940 VSS VSS nch_25od w=10u l=0.5u
M_99 net_6941 net_6942 net_6943 VSS nch_25od w=10u l=0.5u
M_100 VSS I net_6944 VSS nch_25od w=10u l=0.5u
M_101 net_6945 net_6942 net_6946 VSS nch_25od w=10u l=0.5u
M_102 net_6944 POC VSS VSS nch_25od w=2.5u l=0.5u
M_103 net_6944 net_6939 VDDPST VDDPST pch_25od w=3.5u l=1u
M_104 VDDPST net_6944 net_6939 VDDPST pch_25od w=3.5u l=1u
M_105 VSS I net_6946 VSS nch w=10u l=0.09u
M_106 net_6941 net_6940 VSS VSS nch w=10u l=0.09u
M_107 net_6945 I net_6944 VSS nch_na25 w=5.5u l=1.32u
M_108 net_6939 net_6940 net_6943 VSS nch_na25 w=5.5u l=1.32u
M_109 net_6947 net_6948 VSS VSS nch_25od w=10u l=0.5u
M_110 net_6949 net_6942 net_6950 VSS nch_25od w=10u l=0.5u
M_111 VSS OEN net_6951 VSS nch_25od w=10u l=0.5u
M_112 net_6952 net_6942 net_6953 VSS nch_25od w=10u l=0.5u
M_113 net_6951 POC VSS VSS nch_25od w=2.5u l=0.5u
M_114 net_6951 net_6947 VDDPST VDDPST pch_25od w=3.5u l=1u
M_115 VDDPST net_6951 net_6947 VDDPST pch_25od w=3.5u l=1u
M_116 VSS OEN net_6953 VSS nch w=10u l=0.09u
M_117 net_6949 net_6948 VSS VSS nch w=10u l=0.09u
M_118 net_6952 OEN net_6951 VSS nch_na25 w=5.5u l=1.32u
M_119 net_6947 net_6948 net_6950 VSS nch_na25 w=5.5u l=1.32u
M_120 VDDPST net_6954 net_6955 VDDPST pch_25od w=40u l=0.415u
M_121 net_6955 net_6956 VDDPST VDDPST pch_25od w=40u l=0.415u
M_122 net_6957 net_6954 net_6955 VSS nch_25od w=20u l=0.5u
M_123 net_6957 net_6956 VSS VSS nch_25od w=20u l=0.5u
M_124 VSS net_6958 net_6959 VSS nch w=3u l=0.1u
M_125 net_6958 net_6959 VDD VDD pch w=4u l=0.1u
M_126 net_6959 net_6958 net_6958 VDD pch w=4u l=0.1u
M_127 net_6929 POC VSS VSS nch_25od w=3u l=0.5u
M_128 net_6931 net_6960 VSS VSS nch_25od w=20u l=0.5u
M_129 net_6929 REN VSS VSS nch_25od w=20u l=0.5u
M_130 net_6929 net_6931 VDDPST VDDPST pch_25od w=0.5u l=1u
M_131 net_6931 net_6929 VDDPST VDDPST pch_25od w=0.5u l=1u
M_132 net_6942 POC VSS VSS nch_25od w=1u l=0.5u
M_133 net_6942 POC VDDPST VDDPST pch_25od w=2u l=0.415u
X_134 net_6935 PAD rnpolywo w=2u l=3.68u m=1
X_135 net_6961 VSS rppolywo w=1.84u l=2.76u m=1
X_136 VDDPST net_6962 rppolywo w=3.5u l=0.8u m=1
X_137 VDDPST net_6915 rppolywo w=3.5u l=0.8u m=1
D_138 VSS REN ndio area=4p
D_139 VSS OEN ndio area=4p
D_140 VSS I ndio area=4p
M_141 net_6963 net_6939 VSS VSS nch_25od w=2u l=0.5u
M_142 net_6963 net_6939 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_143 net_6956 net_6947 VSS VSS nch_25od w=3u l=0.5u
M_144 net_6956 net_6947 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_145 net_6937 net_6944 VSS VSS nch_25od w=7u l=0.5u
M_146 net_6937 net_6944 VDDPST VDDPST pch_25od w=2u l=0.415u
M_147 net_6954 net_6963 VSS VSS nch_25od w=10u l=0.5u
M_148 net_6954 net_6963 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_149 net_6938 net_6951 VSS VSS nch_25od w=3u l=0.5u
M_150 net_6938 net_6951 VDDPST VDDPST pch_25od w=7.5u l=0.415u
M_151 net_6940 I VSS VSS nch w=3u l=0.09u
M_152 net_6940 I VDD VDD pch w=7.5u l=0.09u
M_153 net_6948 OEN VSS VSS nch w=3u l=0.09u
M_154 net_6948 OEN VDD VDD pch w=7.5u l=0.09u
M_155 net_6960 REN VSS VSS nch w=3u l=0.09u
M_156 net_6960 REN VDD VDD pch w=7.5u l=0.09u
M_157 VSS net_6964 C VSS nch w=20u l=0.09u
M_158 VSS net_6965 net_6964 VSS nch w=10u l=0.09u
M_159 VDD net_6964 C VDD pch w=30u l=0.09u
M_160 VDD net_6965 net_6964 VDD pch w=10u l=0.09u
M_161 VSS net_6933 net_6966 VSS nch_25od w=0.6u l=0.5u
M_162 net_6965 net_6966 VDD VSS nch_25od w=5u l=0.5u
M_163 net_6967 net_6956 VSS VSS nch_25od w=10u l=0.5u
M_164 net_6968 net_6962 net_6967 VSS nch_25od w=10u l=0.5u
M_165 net_6914 net_6962 net_6955 VSS nch_25od w=30u l=0.5u
M_166 VSS net_6933 net_6965 VSS nch_25od w=5u l=0.5u
M_167 net_6935 net_6962 net_6930 VSS nch_25od w=30u l=0.5u
M_168 net_6969 net_6962 net_6968 VSS nch_25od w=10u l=0.5u
M_169 net_6930 net_6938 net_6969 VSS nch_25od w=10u l=0.5u
M_170 VDDPST net_6933 net_6966 VDDPST pch_25od w=1.5u l=0.415u
M_171 net_6968 net_6962 net_6935 net_6928 pch_25od w=26u l=0.415u
M_172 net_6914 net_6968 net_6955 net_6928 pch_25od w=26u l=0.415u
M_173 VDD net_6933 net_6965 VDD pch_25od w=5u l=0.415u
M_174 net_6928 net_6968 VDDPST net_6928 pch_25od w=24u l=0.415u
M_175 net_6928 net_6962 net_6935 net_6928 pch_25od w=24u l=0.415u
M_176 net_6914 net_6962 net_6935 net_6928 pch_25od w=26u l=0.415u
*PGATE NGATE
.ENDS PRUW24DGZ
.SUBCKT PVDD1ANA AVDD
X_0 AVDD net_6970 rppolywo w=0.5u l=606.45u m=1
M_1 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_2 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_3 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_4 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_5 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_6 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_7 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_8 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_9 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_10 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_11 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_12 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_13 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_14 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_15 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_16 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_17 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_18 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_19 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_20 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_21 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_22 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_23 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_24 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_25 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_26 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_27 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_28 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_29 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_30 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_31 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_32 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_33 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_34 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_35 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_36 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_37 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_38 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_39 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_40 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_41 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_42 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_43 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_44 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_45 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_46 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_47 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_48 AVDD net_6971 VSS VSS nch_hvt w=41.6u l=0.13u
M_49 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_50 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_51 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_52 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_53 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_54 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_55 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_56 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_57 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_58 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_59 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_60 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_61 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_62 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_63 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_64 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_65 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_66 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_67 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_68 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_69 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_70 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_71 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_72 net_6971 net_6970 AVDD AVDD pch_25od w=13u l=0.415u
M_73 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_74 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_75 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_76 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_77 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_78 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_79 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_80 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_81 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_82 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_83 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_84 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_85 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_86 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_87 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_88 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_89 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_90 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_91 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_92 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_93 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_94 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_95 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_96 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_97 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_98 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_99 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_100 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_101 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_102 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_103 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_104 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_105 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_106 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_107 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_108 VSS net_6970 VSS VSS nch_25od w=8u l=1.81u
M_109 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_110 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_111 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_112 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_113 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_114 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_115 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_116 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_117 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_118 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_119 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_120 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_121 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_122 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_123 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_124 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_125 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_126 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_127 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_128 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_129 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_130 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_131 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
M_132 net_6971 net_6970 VSS VSS nch_25od w=1.66u l=0.5u
D_133 VSS AVDD ndio_25od area=431.886p
*PGATE NGATE
.ENDS PVDD1ANA
.SUBCKT PVDD1DGZ VDD
X_0 VDD net_6972 rppolywo w=0.5u l=606.45u m=1
M_1 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_2 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_3 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_4 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_5 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_6 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_7 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_8 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_9 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_10 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_11 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_12 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_13 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_14 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_15 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_16 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_17 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_18 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_19 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_20 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_21 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_22 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_23 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_24 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_25 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_26 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_27 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_28 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_29 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_30 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_31 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_32 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_33 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_34 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_35 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_36 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_37 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_38 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_39 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_40 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_41 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_42 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_43 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_44 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_45 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_46 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_47 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_48 VDD net_6973 VSS VSS nch_hvt w=41.6u l=0.13u
M_49 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_50 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_51 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_52 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_53 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_54 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_55 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_56 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_57 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_58 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_59 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_60 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_61 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_62 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_63 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_64 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_65 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_66 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_67 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_68 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_69 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_70 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_71 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_72 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_73 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_74 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_75 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_76 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_77 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_78 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_79 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_80 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_81 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_82 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_83 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_84 VSS net_6972 VSS VSS nch_25od w=8u l=1.81u
M_85 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_86 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_87 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_88 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_89 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_90 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_91 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_92 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_93 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_94 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_95 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_96 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_97 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_98 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_99 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_100 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_101 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_102 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_103 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_104 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_105 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_106 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_107 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_108 net_6973 net_6972 VSS VSS nch_25od w=1.66u l=0.5u
M_109 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_110 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_111 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_112 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_113 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_114 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_115 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_116 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_117 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_118 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_119 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_120 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_121 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_122 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_123 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_124 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_125 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_126 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_127 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_128 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_129 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_130 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_131 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
M_132 net_6973 net_6972 VDD VDD pch_25od w=13u l=0.415u
D_133 VSS VDD ndio_25od area=431.886p
*PGATE NGATE
.ENDS PVDD1DGZ
.SUBCKT PVDD2ANA AVDD
D_0 AVDD VDDPST pdio_25od area=540.54p
D_1 VSS AVDD ndio_esd area=628.176p
M_2 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_3 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_4 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_5 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_6 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_7 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_8 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_9 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_10 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_11 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_12 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_13 AVDD VSS VSS VSS nch_25od w=33u l=0.5u
M_14 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_15 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_16 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_17 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_18 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_19 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_20 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_21 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_22 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_23 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_24 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_25 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_26 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_27 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_28 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
M_29 AVDD VSS VSS VSS nch_25od w=40u l=0.5u
*PGATE NGATE
.ENDS PVDD2ANA
.SUBCKT PVDD2DGZ VDDPST
M_0 VSS net_6974 net_6975 VSS nch w=3u l=0.1u
M_1 net_6974 net_6975 VDD VDD pch w=4u l=0.1u
M_2 net_6975 net_6974 net_6974 VDD pch w=4u l=0.1u
X_3 VDDPST net_6976 rppolywo w=0.5u l=353.85u m=1
X_4 net_6977 net_6978 rppolywo w=0.5u l=985.6u m=1
X_5 net_6976 net_6977 rppolywo w=0.5u l=353.85u m=1
X_6 VSS net_6979 rnpolywo w=2u l=3.68u m=1
M_7 net_6980 net_6979 VSS VSS nch w=2u l=2u
M_8 net_6981 net_6979 net_6980 VSS nch_na25 w=1u l=2u
M_9 net_6982 net_6981 VDDPST VDDPST pch_25od w=12u l=0.415u
M_10 net_6983 net_6984 VDDPST VDDPST pch_25od w=9u l=0.415u
M_11 net_6985 net_6986 VDDPST VDDPST pch_25od w=9u l=0.415u
M_12 net_6983 net_6985 VDDPST VDDPST pch_25od w=9u l=0.415u
M_13 net_6983 net_6985 VDDPST VDDPST pch_25od w=9u l=0.415u
M_14 net_6983 net_6984 VDDPST VDDPST pch_25od w=9u l=0.415u
M_15 net_6984 net_6986 VDDPST VDDPST pch_25od w=9u l=0.415u
M_16 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_17 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_18 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_19 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_20 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_21 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_22 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_23 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_24 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_25 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_26 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_27 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_28 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_29 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_30 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_31 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_32 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_33 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_34 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_35 net_6987 net_6978 VDDPST VDDPST pch_25od w=6u l=0.415u
M_36 net_6981 net_6979 net_6988 VDDPST pch_25od w=1u l=5u
M_37 net_6982 net_6989 VSS VDDPST pch_25od w=12u l=0.415u
M_38 net_6988 net_6979 VDDPST VDDPST pch_25od w=1u l=5u
M_39 net_6986 net_6989 VDDPST VDDPST pch_25od w=9u l=0.415u
M_40 net_6989 net_6981 net_6982 VDDPST pch_25od w=12u l=0.415u
M_41 net_6986 net_6989 VSS VSS nch_25od w=4.5u l=0.5u
M_42 net_6990 net_6981 VSS VSS nch_25od w=5u l=0.5u
M_43 net_6983 net_6984 VSS VSS nch_25od w=4.5u l=0.5u
M_44 net_6983 net_6985 VSS VSS nch_25od w=4.5u l=0.5u
M_45 net_6985 net_6986 VSS VSS nch_25od w=4.5u l=0.5u
M_46 net_6983 net_6984 VSS VSS nch_25od w=4.5u l=0.5u
M_47 net_6983 net_6985 VSS VSS nch_25od w=4.5u l=0.5u
M_48 net_6984 net_6986 VSS VSS nch_25od w=4.5u l=0.5u
M_49 net_6989 net_6981 net_6990 VSS nch_25od w=5u l=0.5u
M_50 VDDPST net_6989 net_6990 VSS nch_25od w=5u l=0.5u
M_51 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_52 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_53 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_54 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_55 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_56 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_57 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_58 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_59 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_60 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_61 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_62 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_63 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_64 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_65 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_66 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_67 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_68 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_69 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_70 VDDPST net_6987 VSS VSS nch_25od w=60.15u l=0.5u
M_71 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_72 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_73 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_74 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_75 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_76 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_77 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_78 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_79 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_80 VSS net_6978 VSS VSS nch_25od w=4u l=4.97u
M_81 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_82 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_83 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_84 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_85 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_86 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_87 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_88 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_89 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
M_90 net_6987 net_6978 VSS VSS nch_25od w=2u l=0.5u
*PGATE NGATE
.ENDS PVDD2DGZ
.SUBCKT PVDD2POC VDDPST
M_0 VSS net_6991 net_6992 VSS nch w=3u l=0.1u
M_1 net_6991 net_6992 VDD VDD pch w=4u l=0.1u
M_2 net_6992 net_6991 net_6991 VDD pch w=4u l=0.1u
X_3 VDDPST net_6993 rppolywo w=0.5u l=353.85u m=1
X_4 net_6994 net_6995 rppolywo w=0.5u l=985.6u m=1
X_5 net_6993 net_6994 rppolywo w=0.5u l=353.85u m=1
X_6 net_6996 VDD rnpolywo w=2u l=3.68u m=1
M_7 net_6997 net_6996 VSS VSS nch w=2u l=2u
M_8 net_6998 net_6996 net_6997 VSS nch_na25 w=1u l=2u
M_9 net_6999 net_6998 VDDPST VDDPST pch_25od w=12u l=0.415u
M_10 POC net_7000 VDDPST VDDPST pch_25od w=9u l=0.415u
M_11 net_7001 net_7002 VDDPST VDDPST pch_25od w=9u l=0.415u
M_12 POC net_7001 VDDPST VDDPST pch_25od w=9u l=0.415u
M_13 POC net_7001 VDDPST VDDPST pch_25od w=9u l=0.415u
M_14 POC net_7000 VDDPST VDDPST pch_25od w=9u l=0.415u
M_15 net_7000 net_7002 VDDPST VDDPST pch_25od w=9u l=0.415u
M_16 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_17 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_18 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_19 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_20 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_21 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_22 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_23 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_24 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_25 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_26 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_27 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_28 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_29 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_30 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_31 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_32 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_33 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_34 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_35 net_7003 net_6995 VDDPST VDDPST pch_25od w=6u l=0.415u
M_36 net_6998 net_6996 net_7004 VDDPST pch_25od w=1u l=5u
M_37 net_6999 net_7005 VSS VDDPST pch_25od w=12u l=0.415u
M_38 net_7004 net_6996 VDDPST VDDPST pch_25od w=1u l=5u
M_39 net_7002 net_7005 VDDPST VDDPST pch_25od w=9u l=0.415u
M_40 net_7005 net_6998 net_6999 VDDPST pch_25od w=12u l=0.415u
M_41 net_7002 net_7005 VSS VSS nch_25od w=4.5u l=0.5u
M_42 net_7006 net_6998 VSS VSS nch_25od w=5u l=0.5u
M_43 POC net_7000 VSS VSS nch_25od w=4.5u l=0.5u
M_44 POC net_7001 VSS VSS nch_25od w=4.5u l=0.5u
M_45 net_7001 net_7002 VSS VSS nch_25od w=4.5u l=0.5u
M_46 POC net_7000 VSS VSS nch_25od w=4.5u l=0.5u
M_47 POC net_7001 VSS VSS nch_25od w=4.5u l=0.5u
M_48 net_7000 net_7002 VSS VSS nch_25od w=4.5u l=0.5u
M_49 net_7005 net_6998 net_7006 VSS nch_25od w=5u l=0.5u
M_50 VDDPST net_7005 net_7006 VSS nch_25od w=5u l=0.5u
M_51 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_52 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_53 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_54 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_55 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_56 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_57 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_58 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_59 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_60 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_61 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_62 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_63 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_64 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_65 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_66 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_67 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_68 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_69 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_70 VDDPST net_7003 VSS VSS nch_25od w=60.15u l=0.5u
M_71 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_72 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_73 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_74 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_75 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_76 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_77 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_78 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_79 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_80 VSS net_6995 VSS VSS nch_25od w=4u l=4.97u
M_81 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_82 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_83 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_84 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_85 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_86 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_87 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_88 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_89 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
M_90 net_7003 net_6995 VSS VSS nch_25od w=2u l=0.5u
*PGATE NGATE
.ENDS PVDD2POC
.SUBCKT PVSS1ANA AVSS
D_0 AVSS VDDPST pdio_25od area=334.815p
D_1 AVSS VSS pdio area=207.54p
D_2 VSS AVSS ndio area=207.54p
*PGATE NGATE
.ENDS PVSS1ANA
.SUBCKT PVSS2ANA AVSS
D_0 VSS AVSS ndio area=207.54p
D_1 AVSS VSS pdio area=207.54p
D_2 AVSS VDDPST pdio_25od area=334.815p
*PGATE NGATE
.ENDS PVSS2ANA
.SUBCKT PVSS3DGZ VSS
D_0 VSS VDD pdio area=96.354p
D_1 VSS VDDPST pdio_25od area=334.815p
*PGATE NGATE
.ENDS PVSS3DGZ
