###############################################################
#  Generated by:      Cadence Innovus 21.18-s099_1
#  OS:                Linux x86_64(Host ID ncdc-0137)
#  Generated on:      Wed Aug 12 04:41:43 2026
#  Design:            top_wrapper
#  Command:           write_lef_abstract /home/cc/Documents/Abdullah/Lab_04_Data/export/Innovus_Data/outputs/pnr/top_wrapper_macro.lef -stripe_pins
###############################################################

VERSION 5.8 ;

BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO top_wrapper
  CLASS BLOCK ;
  SIZE 770.000000 BY 770.000000 ;
  FOREIGN top_wrapper -385.000000 -385.000000 ;
  ORIGIN 0 0 ;
  SYMMETRY X Y R90 ;
  PIN A[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[7]
  PIN A[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[6]
  PIN A[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[5]
  PIN A[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[4]
  PIN A[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[3]
  PIN A[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[2]
  PIN A[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[1]
  PIN A[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A[0]
  PIN B[7]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[7]
  PIN B[6]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[6]
  PIN B[5]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[5]
  PIN B[4]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[4]
  PIN B[3]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[3]
  PIN B[2]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[2]
  PIN B[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[1]
  PIN B[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END B[0]
  PIN Sel[1]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END Sel[1]
  PIN Sel[0]
    DIRECTION INPUT ;
    USE SIGNAL ;
  END Sel[0]
  PIN clk_in
    DIRECTION INPUT ;
    USE SIGNAL ;
  END clk_in
  PIN rst
    DIRECTION INPUT ;
    USE SIGNAL ;
  END rst
  PIN Out[7]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[7]
  PIN Out[6]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[6]
  PIN Out[5]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[5]
  PIN Out[4]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[4]
  PIN Out[3]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[3]
  PIN Out[2]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[2]
  PIN Out[1]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[1]
  PIN Out[0]
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Out[0]
  OBS
    LAYER M1 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M2 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M3 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M4 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M5 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M6 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M7 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M8 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER M9 ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
    LAYER AP ;
      RECT 0.000000 0.000000 770.000000 770.000000 ;
  END
END top_wrapper

END LIBRARY
